** Generated for: hspiceD
** Generated on: Nov 12 18:41:55 2024
** Design library name: acadia
** Design cell name: adc_mixed_tb
** Design view name: schematic
.GLOBAL vss! vdd!

.TEMP 25
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2
+    HIER_DELIM=0
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_bip
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mim
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_dnw
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_bip_npn
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfrtmom
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mos_cap_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_disres
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_res
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_hvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmvar
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_lvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfres_sa
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_esd
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmim
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mos_cap
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25ud18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25ud18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfjvar
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rtmom
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfres_rpo
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_hvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfind
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmvar_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_lvt

** Library name: acadia
** Cell name: three_way_switch
** View name: schematic
.subckt three_way_switch a0 s<0> s<2> s<1> vdd vss y
xm4 y sb<1> vdd vdd pch_mac l=60e-9 w=86.4e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=9.504e-12 as=10.2384e-12 pd=90.8e-6 ps=99.78e-6 nrd=1.27315e-3 nrs=1.27315e-3 sa=195e-9 sb=195e-9 sca=3.04936 scb=2.22233e-3 scc=83.1273e-6 mismatchflag=1
xm11 vdd vdd vdd vdd pch_mac l=60e-9 w=4.32e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=842.4e-15 as=842.4e-15 pd=9.03e-6 ps=9.03e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=12.1482 scb=12.1214e-3 scc=203.839e-6 mismatchflag=1
xm0 sb<1> s<1> vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm2 sb<0> s<0> vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm3 y sb<0> a0 vdd pch_mac l=60e-9 w=86.4e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=9.504e-12 as=10.2384e-12 pd=90.8e-6 ps=99.78e-6 nrd=1.27315e-3 nrs=1.27315e-3 sa=195e-9 sb=195e-9 sca=3.04936 scb=2.22233e-3 scc=83.1273e-6 mismatchflag=1
xm7 a0 a0 a0 vdd pch_mac l=60e-9 w=4.32e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=842.4e-15 as=842.4e-15 pd=9.03e-6 ps=9.03e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=12.1482 scb=12.1214e-3 scc=203.839e-6 mismatchflag=1
xm5 y s<2> vss vss nch_mac l=60e-9 w=43.2e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=4.752e-12 as=5.1192e-12 pd=47.6e-6 ps=52.26e-6 nrd=2.5463e-3 nrs=2.5463e-3 sa=195e-9 sb=195e-9 sca=4.86666 scb=3.86386e-3 scc=159.861e-6 mismatchflag=1
xm8 sb<0> s<0> vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm10 a0 a0 a0 vss nch_mac l=60e-9 w=2.16e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm9 y s<0> a0 vss nch_mac l=60e-9 w=43.2e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=4.752e-12 as=5.1192e-12 pd=47.6e-6 ps=52.26e-6 nrd=2.5463e-3 nrs=2.5463e-3 sa=195e-9 sb=195e-9 sca=4.86666 scb=3.86386e-3 scc=159.861e-6 mismatchflag=1
xm6 sb<1> s<1> vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm12 vss vss vss vss nch_mac l=60e-9 w=2.16e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
.ends three_way_switch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_double_tail_comparator_w_offset_calib
** View name: schematic
.subckt adc_double_tail_comparator_w_offset_calib clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb vdd vin vip vss
xm68 net13 cn<3> net1 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm70 vss vss vss vss nch_mac l=780e-9 w=2.7e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=526.5e-15 as=526.5e-15 pd=5.79e-6 ps=5.79e-6 nrd=40.7407e-3 nrs=40.7407e-3 sa=195e-9 sb=195e-9 sca=7.14619 scb=4.70601e-3 scc=137.589e-6 mismatchflag=1
xm67 net15 cn<2> net1 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm69 vss vss vss vss nch_mac l=780e-9 w=2.7e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=526.5e-15 as=526.5e-15 pd=5.79e-6 ps=5.79e-6 nrd=40.7407e-3 nrs=40.7407e-3 sa=195e-9 sb=195e-9 sca=7.14619 scb=4.70601e-3 scc=137.589e-6 mismatchflag=1
xm62 net15 vin net9 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm45 net27 vip net21 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm44 net18 vip net21 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm28 clkb clk vss vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm60 qb net9 vss vss nch_mac l=780e-9 w=54e-6 multi=1 nf=40 sigma=1 sd=220e-9 ad=5.94e-12 as=6.1695e-12 pd=62.8e-6 ps=65.84e-6 nrd=2.03704e-3 nrs=2.03704e-3 sa=195e-9 sb=195e-9 sca=5.92763 scb=5.30485e-3 scc=245.917e-6 mismatchflag=1
xm22 qb q vss vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=17.1389 scb=17.0454e-3 scc=434.039e-6 mismatchflag=1
xm21 q qb vss vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=17.1389 scb=17.0454e-3 scc=434.039e-6 mismatchflag=1
xm3 q net21 vss vss nch_mac l=780e-9 w=54e-6 multi=1 nf=40 sigma=1 sd=220e-9 ad=5.94e-12 as=6.1695e-12 pd=62.8e-6 ps=65.84e-6 nrd=2.03704e-3 nrs=2.03704e-3 sa=195e-9 sb=195e-9 sca=5.92763 scb=5.30485e-3 scc=245.917e-6 mismatchflag=1
xm2 net9 vin net1 vss nch_mac l=60e-9 w=34.56e-6 multi=1 nf=64 sigma=1 sd=220e-9 ad=3.8016e-12 as=3.8934e-12 pd=48.64e-6 ps=50.06e-6 nrd=3.18287e-3 nrs=3.18287e-3 sa=195e-9 sb=195e-9 sca=12.3017 scb=13.1543e-3 scc=615.828e-6 mismatchflag=1
xm1 net21 vip net1 vss nch_mac l=60e-9 w=34.56e-6 multi=1 nf=64 sigma=1 sd=220e-9 ad=3.8016e-12 as=3.8934e-12 pd=48.64e-6 ps=50.06e-6 nrd=3.18287e-3 nrs=3.18287e-3 sa=195e-9 sb=195e-9 sca=12.3017 scb=13.1543e-3 scc=615.828e-6 mismatchflag=1
xm57 net23 vip net21 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm39 net27 cp<1> net1 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm64 net3 vin net9 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm61 net13 vin net9 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm42 net12 vip net21 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm56 net23 cp<0> net1 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm65 net3 cn<0> net1 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm0 net1 clk vss vss nch_mac l=60e-9 w=200e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=31.7909 scb=38.1391e-3 scc=1.7317e-3 mismatchflag=1
xm37 net18 cp<3> net1 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm72 net1 net1 net1 vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm63 net11 vin net9 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm38 net12 cp<2> net1 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm66 net11 cn<1> net1 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm71 net1 net1 net1 vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm27 clkb clk vdd vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm26 net74 clkb vdd vdd pch_mac l=60e-9 w=200e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=31.7909 scb=38.1391e-3 scc=1.7317e-3 mismatchflag=1
xm25 qb q net74 vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm24 q qb net74 vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm20 net21 clk vdd vdd pch_mac l=60e-9 w=270e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=28.6987 scb=33.4899e-3 scc=1.34375e-3 mismatchflag=1
xm19 net9 clk vdd vdd pch_mac l=60e-9 w=270e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=28.6987 scb=33.4899e-3 scc=1.34375e-3 mismatchflag=1
.ends adc_double_tail_comparator_w_offset_calib
** End of subcircuit definition.

** Library name: acadia
** Cell name: nor2
** View name: schematic
.subckt nor2 a b vdd vss y
m3 y b net1 vdd pch l=180e-9 w=1.08e-6 m=1 nf=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6
m1 net1 a vdd vdd pch l=180e-9 w=1.08e-6 m=1 nf=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6
m2 y b vss vss nch l=180e-9 w=270e-9 m=1 nf=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=26.6525 scb=30.0185e-3 scc=1.27841e-3
m0 y a vss vss nch l=180e-9 w=270e-9 m=1 nf=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=26.6525 scb=30.0185e-3 scc=1.27841e-3
.ends nor2
** End of subcircuit definition.

** Library name: acadia
** Cell name: srlatch
** View name: schematic
.subckt srlatch q qb r s vdd vss
xi2 q s vdd vss qb nor2
xi0 r qb vdd vss q nor2
.ends srlatch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_double_tail_comparator_w_offset_calib_w_srlatch
** View name: schematic
.subckt adc_double_tail_comparator_w_offset_calib_w_srlatch clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb vdd vin vip vss
xi8 net7 cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> strong_q strong_qb vdd vin vip vss adc_double_tail_comparator_w_offset_calib
xi9 q qb strong_q strong_qb vdd vss srlatch
xm2 net7 clk vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm3 net7 clk vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
.ends adc_double_tail_comparator_w_offset_calib_w_srlatch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_cap_dac_8_bit_diff_w_preamp
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_w_preamp ain aip clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> ext_opt ext_vdd_half q qb s0<1> s0<0> s0_top<1> s0_top<0> s1<1> s1<0> s1_top<1> s1_top<0> s2<1> s2<0> s2_top<1> s2_top<0> s3<1> s3<0> s3_top<1> s3_top<0> s4<1> s4<0> s4_top<1> s4_top<0> s5<1> s5<0> s5_top<1> s5_top<0> s6<1> s6<0> s6_top<1> s6_top<0> s7<1> s7<0> s7_top<1> s7_top<0> s8<1> s8<0> s8_top<1> s8_top<0> sc sc1 vdd vdd_half vss
xi59 aip sc s7_top<1> s7_top<0> vdd vss c7_top three_way_switch
xi58 aip sc s4_top<1> s4_top<0> vdd vss c4_top three_way_switch
xi57 aip sc s5_top<1> s5_top<0> vdd vss c5_top three_way_switch
xi56 aip sc s6_top<1> s6_top<0> vdd vss c6_top three_way_switch
xi55 aip sc s3_top<1> s3_top<0> vdd vss c3_top three_way_switch
xi54 aip sc s1_top<1> s1_top<0> vdd vss c1_top three_way_switch
xi53 aip sc s0_top<1> s0_top<0> vdd vss c0_top three_way_switch
xi52 aip sc s2_top<1> s2_top<0> vdd vss c2_top three_way_switch
xi60 ain sc1 s7<1> s7<0> vdd vss c7_bot three_way_switch
xi50 ain sc1 s8<1> s8<0> vdd vss c8_bot three_way_switch
xi49 ain sc1 s2<1> s2<0> vdd vss c2_bot three_way_switch
xi48 ain sc1 s0<1> s0<0> vdd vss c0_bot three_way_switch
xi47 ain sc1 s1<1> s1<0> vdd vss c1_bot three_way_switch
xi46 ain sc1 s3<1> s3<0> vdd vss c3_bot three_way_switch
xi45 ain sc1 s6<1> s6<0> vdd vss c6_bot three_way_switch
xi44 ain sc1 s5<1> s5<0> vdd vss c5_bot three_way_switch
xi43 ain sc1 s4<1> s4<0> vdd vss c4_bot three_way_switch
xi61 aip sc s8_top<1> s8_top<0> vdd vss c8_top three_way_switch
xc45 vin c8_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=128 mismatchflag=1
xc44 vin c1_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc28 vin c0_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc30 vin c3_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=4 mismatchflag=1
xc31 vin c4_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=8 mismatchflag=1
xc32 vin c5_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=16 mismatchflag=1
xc33 vin c6_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=32 mismatchflag=1
xc34 vin c7_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=64 mismatchflag=1
xc35 vip c2_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=2 mismatchflag=1
xc36 vip c7_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=64 mismatchflag=1
xc37 vip c6_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=32 mismatchflag=1
xc38 vip c5_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=16 mismatchflag=1
xc39 vip c4_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=8 mismatchflag=1
xc1 vss vss vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=84 mismatchflag=1
xc0 vss vss vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=84 mismatchflag=1
xc41 vip c0_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc42 vip c1_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc40 vip c3_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=4 mismatchflag=1
xc43 vip c8_top vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=128 mismatchflag=1
xc29 vin c2_bot vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=2 mismatchflag=1
xi41 clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb vdd vin vip vss adc_double_tail_comparator_w_offset_calib_w_srlatch
xm5 scb sc vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm3 vip sc real_vdd_half vss nch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm17 real_vdd_half real_vdd_half real_vdd_half vss nch_mac l=180e-9 w=200e-9 multi=4 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm15 ext_vdd_half ext_vdd_half ext_vdd_half vss nch_mac l=180e-9 w=200e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm0 vin sc real_vdd_half vss nch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm12 vdd_half vdd_half vdd_half vss nch_mac l=180e-9 w=200e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm6 ext_optb ext_opt vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm11 real_vdd_half ext_opt ext_vdd_half vss nch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm8 real_vdd_half ext_optb vdd_half vss nch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm13 vdd_half vdd_half vdd_half vdd pch_mac l=180e-9 w=200e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm1 vin scb real_vdd_half vdd pch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm4 scb sc vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm2 vip scb real_vdd_half vdd pch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm16 real_vdd_half real_vdd_half real_vdd_half vdd pch_mac l=180e-9 w=200e-9 multi=4 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm14 ext_vdd_half ext_vdd_half ext_vdd_half vdd pch_mac l=180e-9 w=200e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=29.7446 scb=34.6678e-3 scc=1.66636e-3 mismatchflag=1
xm7 ext_optb ext_opt vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm10 real_vdd_half ext_optb ext_vdd_half vdd pch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
xm9 real_vdd_half ext_opt vdd_half vdd pch_mac l=180e-9 w=3.2e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=352e-15 as=386e-15 pd=6.72e-6 ps=7.46e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=22.5392 scb=28.1125e-3 scc=1.60846e-3 mismatchflag=1
.ends adc_cap_dac_8_bit_diff_w_preamp
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP16A10TR
** View name: schematic
.subckt FILLCAP16A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=5.17e-6 m=1 nf=1 sd=200e-9 ad=1.00815e-12 as=1.00815e-12 pd=10.73e-6 ps=10.73e-6 nrd=21.2766e-3 nrs=21.2766e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=7.7e-6 m=1 nf=1 sd=200e-9 ad=1.5015e-12 as=1.5015e-12 pd=15.79e-6 ps=15.79e-6 nrd=14.2857e-3 nrs=14.2857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP16A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP4A10TR
** View name: schematic
.subckt FILLCAP4A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=940e-9 m=1 nf=1 sd=200e-9 ad=183.3e-15 as=183.3e-15 pd=2.27e-6 ps=2.27e-6 nrd=117.021e-3 nrs=117.021e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP4A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP32A10TR
** View name: schematic
.subckt FILLCAP32A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=10.81e-6 m=1 nf=1 sd=200e-9 ad=2.10795e-12 as=2.10795e-12 pd=22.01e-6 ps=22.01e-6 nrd=10.1758e-3 nrs=10.1758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=16.1e-6 m=1 nf=1 sd=200e-9 ad=3.1395e-12 as=3.1395e-12 pd=32.59e-6 ps=32.59e-6 nrd=6.8323e-3 nrs=6.8323e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP32A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP3A10TR
** View name: schematic
.subckt FILLCAP3A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP3A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP8A10TR
** View name: schematic
.subckt FILLCAP8A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=2.35e-6 m=1 nf=1 sd=200e-9 ad=458.25e-15 as=458.25e-15 pd=5.09e-6 ps=5.09e-6 nrd=46.8085e-3 nrs=46.8085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=3.5e-6 m=1 nf=1 sd=200e-9 ad=682.5e-15 as=682.5e-15 pd=7.39e-6 ps=7.39e-6 nrd=31.4286e-3 nrs=31.4286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP8A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP64A10TR
** View name: schematic
.subckt FILLCAP64A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=22.56e-6 m=1 nf=1 sd=200e-9 ad=4.3992e-12 as=4.3992e-12 pd=45.51e-6 ps=45.51e-6 nrd=4.87589e-3 nrs=4.87589e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=130e-9 w=33.6e-6 m=1 nf=1 sd=200e-9 ad=6.552e-12 as=6.552e-12 pd=67.59e-6 ps=67.59e-6 nrd=3.27381e-3 nrs=3.27381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP64A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX1MA10TR
** View name: schematic
.subckt INVX1MA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND2X1BA10TR
** View name: schematic
.subckt NAND2X1BA10TR a b y inh_ground inh_power
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND2X1BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2BX1MA10TR
** View name: schematic
.subckt NOR2BX1MA10TR an b y inh_ground inh_power
mna2 y b inh_ground inh_ground nch l=60e-9 w=285e-9 m=1 nf=1 sd=200e-9 ad=55.575e-15 as=55.575e-15 pd=960e-9 ps=960e-9 nrd=385.965e-3 nrs=385.965e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 net24 an inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net24 inh_ground inh_ground nch l=60e-9 w=285e-9 m=1 nf=1 sd=200e-9 ad=55.575e-15 as=55.575e-15 pd=960e-9 ps=960e-9 nrd=385.965e-3 nrs=385.965e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 net24 an inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net24 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2BX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AND2X1MA10TR
** View name: schematic
.subckt AND2X1MA10TR a b y inh_ground inh_power
mna1 int a n1 inh_ground nch l=60e-9 w=305e-9 m=1 nf=1 sd=200e-9 ad=59.475e-15 as=59.475e-15 pd=1e-6 ps=1e-6 nrd=360.656e-3 nrs=360.656e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=305e-9 m=1 nf=1 sd=200e-9 ad=59.475e-15 as=59.475e-15 pd=1e-6 ps=1e-6 nrd=360.656e-3 nrs=360.656e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 y int inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 int a inh_power inh_power pch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 y int inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b inh_power inh_power pch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AND2X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2X1AA10TR
** View name: schematic
.subckt NOR2X1AA10TR a b y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2X1AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI21X1MA10TR
** View name: schematic
.subckt OAI21X1MA10TR a0 a1 b0 y inh_ground inh_power
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1 inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 inh_power inh_power pch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI21X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND4X1AA10TR
** View name: schematic
.subckt NAND4X1AA10TR a b c d y inh_ground inh_power
mna4 n1 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n2 c n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n3 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n3 b n2 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa4 y d inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND4X1AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI211X1MA10TR
** View name: schematic
.subckt OAI211X1MA10TR a0 a1 b0 c0 y inh_ground inh_power
mna1 y c0 n2 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n2 b0 n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnc2 n1 a1 inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnc1 n1 a0 inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc1 y a0 p1 inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y c0 inh_power inh_power pch l=60e-9 w=360e-9 m=1 nf=1 sd=200e-9 ad=70.2e-15 as=70.2e-15 pd=1.11e-6 ps=1.11e-6 nrd=305.556e-3 nrs=305.556e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc2 p1 a1 inh_power inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y b0 inh_power inh_power pch l=60e-9 w=360e-9 m=1 nf=1 sd=200e-9 ad=70.2e-15 as=70.2e-15 pd=1.11e-6 ps=1.11e-6 nrd=305.556e-3 nrs=305.556e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI211X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AO22X1MA10TR
** View name: schematic
.subckt AO22X1MA10TR a0 a1 b0 b1 y inh_ground inh_power
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 int a0 n1b inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 int b0 n1a inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa109 int b0 p1 inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b1 p1 inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AO22X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR3X1AA10TR
** View name: schematic
.subckt NOR3X1AA10TR a b c y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 y c inh_ground inh_ground nch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 p1 c inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p2 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p2 b p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR3X1AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI22X1MA10TR
** View name: schematic
.subckt AOI22X1MA10TR a0 a1 b0 b1 y inh_ground inh_power
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1a inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 y a0 n1b inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b1 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI22X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI31X1MA10TR
** View name: schematic
.subckt AOI31X1MA10TR a0 a1 a2 b0 y inh_ground inh_power
mnb1 y a0 n2 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb3 n1 a2 inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n2 a1 n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 inh_ground inh_ground nch l=60e-9 w=270e-9 m=1 nf=1 sd=200e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb3 p1 a2 inh_power inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=665e-9 m=1 nf=1 sd=200e-9 ad=129.675e-15 as=129.675e-15 pd=1.72e-6 ps=1.72e-6 nrd=165.413e-3 nrs=165.413e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI31X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND3X1AA10TR
** View name: schematic
.subckt NAND3X1AA10TR a b c y inh_ground inh_power
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n2 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=540e-9 m=1 nf=1 sd=200e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=540e-9 m=1 nf=1 sd=200e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=540e-9 m=1 nf=1 sd=200e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND3X1AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: XOR2X1MA10TR
** View name: schematic
.subckt XOR2X1MA10TR a b y inh_ground inh_power
mna108 nin1 a inh_ground inh_ground nch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nin2 b inh_ground inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe y a nin2 inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe02 y nin1 bin2 inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 bin2 nin2 inh_ground inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen04 y a bin2 inh_power pch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 nin1 a inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nin2 b inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen y nin1 nin2 inh_power pch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 bin2 nin2 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends XOR2X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI221X1MA10TR
** View name: schematic
.subckt AOI221X1MA10TR a0 a1 b0 b1 c0 y inh_ground inh_power
mn4 y a0 net17 inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net26 b1 inh_ground inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 y b0 net26 inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 p2 b1 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p2 b0 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 p2 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI221X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI22X1MA10TR
** View name: schematic
.subckt OAI22X1MA10TR a0 a1 b0 b1 y inh_ground inh_power
mna1 y b0 n1 inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b1 n1 inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1a inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1b inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1a b1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1b a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI22X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX3MA10TR
** View name: schematic
.subckt INVX3MA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=1.59e-6 m=1 nf=1 sd=200e-9 ad=310.05e-15 as=310.05e-15 pd=3.57e-6 ps=3.57e-6 nrd=69.1824e-3 nrs=69.1824e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AND3X1MA10TR
** View name: schematic
.subckt AND3X1MA10TR a b c y inh_ground inh_power
mna102 int a n2 inh_ground nch l=60e-9 w=505e-9 m=1 nf=1 sd=200e-9 ad=98.475e-15 as=98.475e-15 pd=1.4e-6 ps=1.4e-6 nrd=217.822e-3 nrs=217.822e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=505e-9 m=1 nf=1 sd=200e-9 ad=98.475e-15 as=98.475e-15 pd=1.4e-6 ps=1.4e-6 nrd=217.822e-3 nrs=217.822e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=505e-9 m=1 nf=1 sd=200e-9 ad=98.475e-15 as=98.475e-15 pd=1.4e-6 ps=1.4e-6 nrd=217.822e-3 nrs=217.822e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 int c inh_power inh_power pch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa105 int a inh_power inh_power pch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b inh_power inh_power pch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AND3X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AND4X0P7MA10TR
** View name: schematic
.subckt AND4X0P7MA10TR a b c d y inh_ground inh_power
mna2 n3 b n2 inh_ground nch l=60e-9 w=575e-9 m=1 nf=1 sd=200e-9 ad=112.125e-15 as=112.125e-15 pd=1.54e-6 ps=1.54e-6 nrd=191.304e-3 nrs=191.304e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n2 c n1 inh_ground nch l=60e-9 w=575e-9 m=1 nf=1 sd=200e-9 ad=112.125e-15 as=112.125e-15 pd=1.54e-6 ps=1.54e-6 nrd=191.304e-3 nrs=191.304e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 int a n3 inh_ground nch l=60e-9 w=575e-9 m=1 nf=1 sd=200e-9 ad=112.125e-15 as=112.125e-15 pd=1.54e-6 ps=1.54e-6 nrd=191.304e-3 nrs=191.304e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna4 n1 d inh_ground inh_ground nch l=60e-9 w=575e-9 m=1 nf=1 sd=200e-9 ad=112.125e-15 as=112.125e-15 pd=1.54e-6 ps=1.54e-6 nrd=191.304e-3 nrs=191.304e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 int c inh_power inh_power pch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa105 int a inh_power inh_power pch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b inh_power inh_power pch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa4 int d inh_power inh_power pch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AND4X0P7MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OA211X0P7MA10TR
** View name: schematic
.subckt OA211X0P7MA10TR a0 a1 b0 c0 y inh_ground inh_power
mnc2 n1 a1 inh_ground inh_ground nch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n2 b0 n1 inh_ground nch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnc1 n1 a0 inh_ground inh_ground nch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 int c0 n2 inh_ground nch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 y int inh_ground inh_ground nch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc1 int a0 p1 inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 int b0 inh_power inh_power pch l=60e-9 w=305e-9 m=1 nf=1 sd=200e-9 ad=59.475e-15 as=59.475e-15 pd=1e-6 ps=1e-6 nrd=360.656e-3 nrs=360.656e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 y int inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 int c0 inh_power inh_power pch l=60e-9 w=305e-9 m=1 nf=1 sd=200e-9 ad=59.475e-15 as=59.475e-15 pd=1e-6 ps=1e-6 nrd=360.656e-3 nrs=360.656e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc2 p1 a1 inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OA211X0P7MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OR6X1MA10TR
** View name: schematic
.subckt OR6X1MA10TR a b c d e f y inh_ground inh_power
mna3 int1 c inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3010 int2 f inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna208 int2 e inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 int1 a inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 int1 b inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 int2 d inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2020 n1 int2 inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1018 y int1 n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2024 y int2 inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p2 b p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3016 p1_4 f inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 p1 c inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2014 p2_6 e p1_4 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 int1 a p2 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1012 int2 d p2_6 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1022 y int1 inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OR6X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND2BX1MA10TR
** View name: schematic
.subckt NAND2BX1MA10TR an b y inh_ground inh_power
mna104 net24 an inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net24 n1 inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 net24 an inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net24 inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND2BX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND3X3AA10TR
** View name: schematic
.subckt NAND3X3AA10TR a b c y inh_ground inh_power
mna1 y a n2 inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=1.62e-6 m=1 nf=1 sd=200e-9 ad=315.9e-15 as=315.9e-15 pd=3.63e-6 ps=3.63e-6 nrd=67.9012e-3 nrs=67.9012e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=1.62e-6 m=1 nf=1 sd=200e-9 ad=315.9e-15 as=315.9e-15 pd=3.63e-6 ps=3.63e-6 nrd=67.9012e-3 nrs=67.9012e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=1.62e-6 m=1 nf=1 sd=200e-9 ad=315.9e-15 as=315.9e-15 pd=3.63e-6 ps=3.63e-6 nrd=67.9012e-3 nrs=67.9012e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND3X3AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND4X0P5MA10TR
** View name: schematic
.subckt NAND4X0P5MA10TR a b c d y inh_ground inh_power
mna4 n1 d inh_ground inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n2 c n1 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n3 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n3 b n2 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa4 y d inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND4X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2X0P5MA10TR
** View name: schematic
.subckt NOR2X0P5MA10TR a b y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX0P5BA10TR
** View name: schematic
.subckt INVX0P5BA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX0P5BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI221X0P5MA10TR
** View name: schematic
.subckt AOI221X0P5MA10TR a0 a1 b0 b1 c0 y inh_ground inh_power
mn4 y a0 net17 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net26 b1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 y b0 net26 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 p2 b1 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 p2 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p2 b0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI221X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI22X0P5MA10TR
** View name: schematic
.subckt AOI22X0P5MA10TR a0 a1 b0 b1 y inh_ground inh_power
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 y a0 n1b inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1a inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b1 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI22X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI211X0P5MA10TR
** View name: schematic
.subckt OAI211X0P5MA10TR a0 a1 b0 c0 y inh_ground inh_power
mnc2 n1 a1 inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnc1 n1 a0 inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n2 b0 n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y c0 n2 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc2 p1 a1 inh_power inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y c0 inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc1 y a0 p1 inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y b0 inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI211X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AO22X0P5MA10TR
** View name: schematic
.subckt AO22X0P5MA10TR a0 a1 b0 b1 y inh_ground inh_power
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 int a0 n1b inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 int b0 n1a inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b1 p1 inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa109 int b0 p1 inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AO22X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI21X0P5MA10TR
** View name: schematic
.subckt OAI21X0P5MA10TR a0 a1 b0 y inh_ground inh_power
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 inh_power inh_power pch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI21X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: XOR2X0P5MA10TR
** View name: schematic
.subckt XOR2X0P5MA10TR a b y inh_ground inh_power
mna108 nin1 a inh_ground inh_ground nch l=60e-9 w=275e-9 m=1 nf=1 sd=200e-9 ad=53.625e-15 as=53.625e-15 pd=940e-9 ps=940e-9 nrd=400e-3 nrs=400e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nin2 b inh_ground inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe y a nin2 inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe02 y nin1 bin2 inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 bin2 nin2 inh_ground inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen04 y a bin2 inh_power pch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 nin1 a inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nin2 b inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen y nin1 nin2 inh_power pch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 bin2 nin2 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends XOR2X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND3X0P5MA10TR
** View name: schematic
.subckt NAND3X0P5MA10TR a b c y inh_ground inh_power
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n2 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND3X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX1MA10TR
** View name: schematic
.subckt DFFRPQX1MA10TR ck d q r inh_ground inh_power
mna1014 m r inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm nclk net055 inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net055 d inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net139 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net139 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1024 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm bclk net055 inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net055 d inh_power inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1026 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1017 m r p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net123 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net129 ns net123 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net129 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX2MA10TR
** View name: schematic
.subckt DFFRPQX2MA10TR ck d q r inh_ground inh_power
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1013 m r inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm nclk net32 inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=210e-9 m=1 nf=1 sd=200e-9 ad=40.95e-15 as=40.95e-15 pd=810e-9 ps=810e-9 nrd=523.81e-3 nrs=523.81e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net32 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=1.06e-6 m=1 nf=1 sd=200e-9 ad=206.7e-15 as=206.7e-15 pd=2.51e-6 ps=2.51e-6 nrd=103.774e-3 nrs=103.774e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net106 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net106 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1024 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=360e-9 m=1 nf=1 sd=200e-9 ad=70.2e-15 as=70.2e-15 pd=1.11e-6 ps=1.11e-6 nrd=305.556e-3 nrs=305.556e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm bclk net32 inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=260e-9 m=1 nf=1 sd=200e-9 ad=50.7e-15 as=50.7e-15 pd=910e-9 ps=910e-9 nrd=423.077e-3 nrs=423.077e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net32 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1026 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1016 m r p1 inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net96 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net102 ns net96 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net102 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX2MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX0P5MA10TR
** View name: schematic
.subckt DFFRPQX0P5MA10TR ck d q r inh_ground inh_power
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1018 m nm inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe036 nm nclk nin inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nin d inh_ground inh_ground nch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net63 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net63 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1028 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen038 nm bclk nin inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nin d inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 r inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1021 m nm p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1030 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net77 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net83 ns net77 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net83 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX3MA10TR
** View name: schematic
.subckt DFFRPQX3MA10TR ck d q r inh_ground inh_power
mna105 bclk nclk inh_ground inh_ground nch l=60e-9 w=210e-9 m=1 nf=1 sd=200e-9 ad=40.95e-15 as=40.95e-15 pd=810e-9 ps=810e-9 nrd=523.81e-3 nrs=523.81e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm nclk net055 inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1032 ns s inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1010 m r inh_ground inh_ground nch l=60e-9 w=430e-9 m=1 nf=1 sd=200e-9 ad=83.85e-15 as=83.85e-15 pd=1.25e-6 ps=1.25e-6 nrd=255.814e-3 nrs=255.814e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=430e-9 m=1 nf=1 sd=200e-9 ad=83.85e-15 as=83.85e-15 pd=1.25e-6 ps=1.25e-6 nrd=255.814e-3 nrs=255.814e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net055 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net140 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net140 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe024 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1034 ns s inh_power inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa107 bclk nclk inh_power inh_power pch l=60e-9 w=420e-9 m=1 nf=1 sd=200e-9 ad=81.9e-15 as=81.9e-15 pd=1.23e-6 ps=1.23e-6 nrd=261.905e-3 nrs=261.905e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm bclk net055 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net055 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1022 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen026 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1013 m r p1 inh_power pch l=60e-9 w=850e-9 m=1 nf=1 sd=200e-9 ad=165.75e-15 as=165.75e-15 pd=2.09e-6 ps=2.09e-6 nrd=129.412e-3 nrs=129.412e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=850e-9 m=1 nf=1 sd=200e-9 ad=165.75e-15 as=165.75e-15 pd=2.09e-6 ps=2.09e-6 nrd=129.412e-3 nrs=129.412e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net124 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net118 ns net124 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net118 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFSQX3MA10TR
** View name: schematic
.subckt DFFSQX3MA10TR ck d q sn inh_ground inh_power
mna106 bclk nclk inh_ground inh_ground nch l=60e-9 w=210e-9 m=1 nf=1 sd=200e-9 ad=40.95e-15 as=40.95e-15 pd=810e-9 ps=810e-9 nrd=523.81e-3 nrs=523.81e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe022 nm nclk net0105 inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1030 ns s inh_ground inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe026 s bclk m inh_ground nch l=60e-9 w=440e-9 m=1 nf=1 sd=200e-9 ad=85.8e-15 as=85.8e-15 pd=1.27e-6 ps=1.27e-6 nrd=250e-3 nrs=250e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1_12 nm inh_ground inh_ground nch l=60e-9 w=660e-9 m=1 nf=1 sd=200e-9 ad=128.7e-15 as=128.7e-15 pd=1.71e-6 ps=1.71e-6 nrd=166.667e-3 nrs=166.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1038 m sn n1_12 inh_ground nch l=60e-9 w=660e-9 m=1 nf=1 sd=200e-9 ad=128.7e-15 as=128.7e-15 pd=1.71e-6 ps=1.71e-6 nrd=166.667e-3 nrs=166.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 q ns inh_ground inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1034 net0105 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn8 net52 sn inh_ground inh_ground nch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn9 net49 ns net52 inh_ground nch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn7 s nclk net49 inh_ground nch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp9 s sn inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1032 ns s inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen024 nm bclk net0105 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1041 m sn inh_power inh_power pch l=60e-9 w=620e-9 m=1 nf=1 sd=200e-9 ad=120.9e-15 as=120.9e-15 pd=1.63e-6 ps=1.63e-6 nrd=177.419e-3 nrs=177.419e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 bclk nclk inh_power inh_power pch l=60e-9 w=420e-9 m=1 nf=1 sd=200e-9 ad=81.9e-15 as=81.9e-15 pd=1.23e-6 ps=1.23e-6 nrd=261.905e-3 nrs=261.905e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 m nm inh_power inh_power pch l=60e-9 w=620e-9 m=1 nf=1 sd=200e-9 ad=120.9e-15 as=120.9e-15 pd=1.63e-6 ps=1.63e-6 nrd=177.419e-3 nrs=177.419e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen028 s nclk m inh_power pch l=60e-9 w=440e-9 m=1 nf=1 sd=200e-9 ad=85.8e-15 as=85.8e-15 pd=1.27e-6 ps=1.27e-6 nrd=250e-3 nrs=250e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp7 net66 ns inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp8 s bclk net66 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 q ns inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1036 net0105 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm nclk p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFSQX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: ADDFX1MA10TR
** View name: schematic
.subckt ADDFX1MA10TR a b ci co s inh_ground inh_power
mn7 nsum ncout n2 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 ncout ci n1 inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 n2 a inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn8 n2 b inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 n1 b inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn6 n2 ci inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 a inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 net34 b inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 ncout a net34 inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 co ncout inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1022 s nsum inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn11 net46 b inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn10 net49 a net46 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn9 nsum ci net49 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 ncout ci p1 inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 p1 a inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p1 b inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp7 nsum ncout p2 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p2 a inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp6 p2 ci inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp8 p2 b inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 ncout a net69 inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 net69 b inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 co ncout inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1024 s nsum inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp11 net84 b inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp10 net87 a net84 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp9 nsum ci net87 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends ADDFX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQNX1MA10TR
** View name: schematic
.subckt DFFRPQNX1MA10TR ck d qn r inh_ground inh_power
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 net37 s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1034 m r inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe014 nm nclk nin inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe018 s bclk m inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 nin d inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net53 net37 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net53 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1022 nclk ck inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1030 qn s inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm nclk p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net37 s inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen016 nm bclk nin inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 bclk nclk inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen020 s nclk m inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 nin d inh_power inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1037 m r p1_12 inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_12 nm inh_power inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1024 nclk ck inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1032 qn s inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net36 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net39 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net36 net37 net39 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQNX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: PREICGX3BA10TR
** View name: schematic
.subckt PREICGX3BA10TR ck e eck se inh_ground inh_power
mna1026 eck nout inh_ground inh_ground nch l=60e-9 w=1.08e-6 m=1 nf=1 sd=200e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 m nm inh_ground inh_ground nch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nclk_ ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm nclk_ nen inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 m inh_ground inh_ground nch l=60e-9 w=520e-9 m=1 nf=1 sd=200e-9 ad=101.4e-15 as=101.4e-15 pd=1.43e-6 ps=1.43e-6 nrd=211.538e-3 nrs=211.538e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 nout ck n1 inh_ground nch l=60e-9 w=520e-9 m=1 nf=1 sd=200e-9 ad=101.4e-15 as=101.4e-15 pd=1.43e-6 ps=1.43e-6 nrd=211.538e-3 nrs=211.538e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1_6 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe05 nm ck n1_6 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 nen se inh_ground inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 nen e inh_ground inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nclk_ ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 m nm inh_power inh_power pch l=60e-9 w=270e-9 m=1 nf=1 sd=200e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 eck nout inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm ck nen inh_power pch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 nout ck inh_power inh_power pch l=60e-9 w=630e-9 m=1 nf=1 sd=200e-9 ad=122.85e-15 as=122.85e-15 pd=1.65e-6 ps=1.65e-6 nrd=174.603e-3 nrs=174.603e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 nout m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen07 nm nclk_ p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1023 nen e p1_9 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_9 se inh_power inh_power pch l=60e-9 w=560e-9 m=1 nf=1 sd=200e-9 ad=109.2e-15 as=109.2e-15 pd=1.51e-6 ps=1.51e-6 nrd=196.429e-3 nrs=196.429e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends PREICGX3BA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX3BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: PREICGX2BA10TR
** View name: schematic
.subckt PREICGX2BA10TR ck e eck se inh_ground inh_power
mn0 nout ck n1 inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe05 nm ck n1_6 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 eck nout inh_ground inh_ground nch l=60e-9 w=720e-9 m=1 nf=1 sd=200e-9 ad=140.4e-15 as=140.4e-15 pd=1.83e-6 ps=1.83e-6 nrd=152.778e-3 nrs=152.778e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1_6 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nclk_ ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 m nm inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm nclk_ nen inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 m inh_ground inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 nen se inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 nen e inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nclk_ ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 eck nout inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm ck nen inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 m nm inh_power inh_power pch l=60e-9 w=215e-9 m=1 nf=1 sd=200e-9 ad=41.925e-15 as=41.925e-15 pd=820e-9 ps=820e-9 nrd=511.628e-3 nrs=511.628e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 nout ck inh_power inh_power pch l=60e-9 w=410e-9 m=1 nf=1 sd=200e-9 ad=79.95e-15 as=79.95e-15 pd=1.21e-6 ps=1.21e-6 nrd=268.293e-3 nrs=268.293e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 nout m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen07 nm nclk_ p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1023 nen e p1_9 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_9 se inh_power inh_power pch l=60e-9 w=560e-9 m=1 nf=1 sd=200e-9 ad=109.2e-15 as=109.2e-15 pd=1.51e-6 ps=1.51e-6 nrd=196.429e-3 nrs=196.429e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends PREICGX2BA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX3BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFX2MA10TR
** View name: schematic
.subckt BUFX2MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=1.06e-6 m=1 nf=1 sd=200e-9 ad=206.7e-15 as=206.7e-15 pd=2.51e-6 ps=2.51e-6 nrd=103.774e-3 nrs=103.774e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=420e-9 m=1 nf=1 sd=200e-9 ad=81.9e-15 as=81.9e-15 pd=1.23e-6 ps=1.23e-6 nrd=261.905e-3 nrs=261.905e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFX2MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFX3MA10TR
** View name: schematic
.subckt BUFX3MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=1.59e-6 m=1 nf=1 sd=200e-9 ad=310.05e-15 as=310.05e-15 pd=3.57e-6 ps=3.57e-6 nrd=69.1824e-3 nrs=69.1824e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=635e-9 m=1 nf=1 sd=200e-9 ad=123.825e-15 as=123.825e-15 pd=1.66e-6 ps=1.66e-6 nrd=173.228e-3 nrs=173.228e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: TIEHIX1MA10TR
** View name: schematic
.subckt TIEHIX1MA10TR y inh_ground inh_power
mn1 lo hi inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 lo lo inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 y lo inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 hi lo inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends TIEHIX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: TIELOX1MA10TR
** View name: schematic
.subckt TIELOX1MA10TR y inh_ground inh_power
mn0 y hi inh_ground inh_ground nch l=60e-9 w=550e-9 m=1 nf=1 sd=200e-9 ad=107.25e-15 as=107.25e-15 pd=1.49e-6 ps=1.49e-6 nrd=200e-3 nrs=200e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 lo hi inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 hi hi inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 hi lo inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends TIELOX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DLY4X0P5MA10TR
** View name: schematic
.subckt DLY4X0P5MA10TR a y inh_ground inh_power
mnoe014 nin a n1_5 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1010 n1_5 a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 inh_ground nbin inh_ground inh_ground nch l=60e-9 w=185e-9 m=1 nf=1 sd=200e-9 ad=36.075e-15 as=36.075e-15 pd=760e-9 ps=760e-9 nrd=594.595e-3 nrs=594.595e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1018 n1_9 nin inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe022 bin nin n1_9 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1 bin inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nbin bin n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 y nbin inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1012 p1_7 a inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 inh_power nbin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen016 nin a p1_7 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 y nbin inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nbin bin p1 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 bin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1020 p1_11 nin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen024 bin nin p1_11 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DLY4X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DLY2X0P5MA10TR
** View name: schematic
.subckt DLY2X0P5MA10TR a y inh_ground inh_power
mn0 inh_ground net15 inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 n1 a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe net15 a n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net15 inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 inh_power net15 inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net15 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 p1 a inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen net15 a p1 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DLY2X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFHX1MA10TR
** View name: schematic
.subckt BUFHX1MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFHX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFHX0P7MA10TR
** View name: schematic
.subckt BUFHX0P7MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=260e-9 m=1 nf=1 sd=200e-9 ad=50.7e-15 as=50.7e-15 pd=910e-9 ps=910e-9 nrd=423.077e-3 nrs=423.077e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=345e-9 m=1 nf=1 sd=200e-9 ad=67.275e-15 as=67.275e-15 pd=1.08e-6 ps=1.08e-6 nrd=318.841e-3 nrs=318.841e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFHX0P7MA10TR
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_cap_dac_8_bit_diff_digital_top_verilog
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_digital_top_verilog clk rst firm_en adc_en calib_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> eoc_n comp_result s_c s_c1 dac_switches_top_0<1> dac_switches_top_0<0> dac_switches_bot_0<1> dac_switches_bot_0<0> dac_switches_top_1<1> dac_switches_top_1<0> dac_switches_bot_1<1> dac_switches_bot_1<0> dac_switches_top_2<1> dac_switches_top_2<0> dac_switches_bot_2<1> dac_switches_bot_2<0> dac_switches_top_3<1> dac_switches_top_3<0> dac_switches_bot_3<1> dac_switches_bot_3<0> dac_switches_top_4<1> dac_switches_top_4<0> dac_switches_bot_4<1> dac_switches_bot_4<0> dac_switches_top_5<1> dac_switches_top_5<0> dac_switches_bot_5<1> dac_switches_bot_5<0> dac_switches_top_6<1> dac_switches_top_6<0> dac_switches_bot_6<1> dac_switches_bot_6<0> dac_switches_top_7<1> dac_switches_top_7<0> dac_switches_bot_7<1> dac_switches_bot_7<0> dummy_switch_top<1> dummy_switch_top<0> dummy_switch_bot<1> dummy_switch_bot<0> cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> inh_vdd inh_vss inh_ground inh_power
vthru0 fe_rn_1 s_c DC=0
xfill_t_3_57 inh_ground inh_power FILLCAP16A10TR
xfill_t_3_54 inh_ground inh_power FILLCAP16A10TR
xfill_t_3_19 inh_ground inh_power FILLCAP16A10TR
xfill_t_2_243 inh_ground inh_power FILLCAP16A10TR
xfill_t_2_226 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_2 inh_ground inh_power FILLCAP16A10TR
xpcap_300 inh_ground inh_power FILLCAP16A10TR
xpcap_299 inh_ground inh_power FILLCAP16A10TR
xpcap_298 inh_ground inh_power FILLCAP16A10TR
xpcap_297 inh_ground inh_power FILLCAP16A10TR
xpcap_296 inh_ground inh_power FILLCAP16A10TR
xpcap_295 inh_ground inh_power FILLCAP16A10TR
xpcap_294 inh_ground inh_power FILLCAP16A10TR
xpcap_293 inh_ground inh_power FILLCAP16A10TR
xpcap_292 inh_ground inh_power FILLCAP16A10TR
xpcap_291 inh_ground inh_power FILLCAP16A10TR
xpcap_290 inh_ground inh_power FILLCAP16A10TR
xpcap_289 inh_ground inh_power FILLCAP16A10TR
xpcap_288 inh_ground inh_power FILLCAP16A10TR
xpcap_287 inh_ground inh_power FILLCAP16A10TR
xpcap_286 inh_ground inh_power FILLCAP16A10TR
xpcap_285 inh_ground inh_power FILLCAP16A10TR
xpcap_284 inh_ground inh_power FILLCAP16A10TR
xpcap_283 inh_ground inh_power FILLCAP16A10TR
xpcap_282 inh_ground inh_power FILLCAP16A10TR
xpcap_281 inh_ground inh_power FILLCAP16A10TR
xpcap_280 inh_ground inh_power FILLCAP16A10TR
xpcap_279 inh_ground inh_power FILLCAP16A10TR
xpcap_278 inh_ground inh_power FILLCAP16A10TR
xpcap_277 inh_ground inh_power FILLCAP16A10TR
xpcap_276 inh_ground inh_power FILLCAP16A10TR
xpcap_275 inh_ground inh_power FILLCAP16A10TR
xpcap_274 inh_ground inh_power FILLCAP16A10TR
xpcap_273 inh_ground inh_power FILLCAP16A10TR
xpcap_272 inh_ground inh_power FILLCAP16A10TR
xpcap_271 inh_ground inh_power FILLCAP16A10TR
xpcap_270 inh_ground inh_power FILLCAP16A10TR
xpcap_269 inh_ground inh_power FILLCAP16A10TR
xpcap_268 inh_ground inh_power FILLCAP16A10TR
xpcap_267 inh_ground inh_power FILLCAP16A10TR
xpcap_266 inh_ground inh_power FILLCAP16A10TR
xpcap_265 inh_ground inh_power FILLCAP16A10TR
xpcap_264 inh_ground inh_power FILLCAP16A10TR
xpcap_263 inh_ground inh_power FILLCAP16A10TR
xpcap_262 inh_ground inh_power FILLCAP16A10TR
xpcap_261 inh_ground inh_power FILLCAP16A10TR
xpcap_260 inh_ground inh_power FILLCAP16A10TR
xpcap_259 inh_ground inh_power FILLCAP16A10TR
xpcap_258 inh_ground inh_power FILLCAP16A10TR
xpcap_257 inh_ground inh_power FILLCAP16A10TR
xpcap_256 inh_ground inh_power FILLCAP16A10TR
xpcap_255 inh_ground inh_power FILLCAP16A10TR
xpcap_254 inh_ground inh_power FILLCAP16A10TR
xpcap_253 inh_ground inh_power FILLCAP16A10TR
xpcap_252 inh_ground inh_power FILLCAP16A10TR
xpcap_251 inh_ground inh_power FILLCAP16A10TR
xpcap_250 inh_ground inh_power FILLCAP16A10TR
xpcap_249 inh_ground inh_power FILLCAP16A10TR
xpcap_248 inh_ground inh_power FILLCAP16A10TR
xpcap_247 inh_ground inh_power FILLCAP16A10TR
xpcap_246 inh_ground inh_power FILLCAP16A10TR
xpcap_245 inh_ground inh_power FILLCAP16A10TR
xpcap_244 inh_ground inh_power FILLCAP16A10TR
xpcap_243 inh_ground inh_power FILLCAP16A10TR
xpcap_242 inh_ground inh_power FILLCAP16A10TR
xpcap_241 inh_ground inh_power FILLCAP16A10TR
xpcap_240 inh_ground inh_power FILLCAP16A10TR
xpcap_239 inh_ground inh_power FILLCAP16A10TR
xpcap_238 inh_ground inh_power FILLCAP16A10TR
xpcap_237 inh_ground inh_power FILLCAP16A10TR
xpcap_236 inh_ground inh_power FILLCAP16A10TR
xpcap_235 inh_ground inh_power FILLCAP16A10TR
xpcap_234 inh_ground inh_power FILLCAP16A10TR
xpcap_233 inh_ground inh_power FILLCAP16A10TR
xpcap_232 inh_ground inh_power FILLCAP16A10TR
xpcap_231 inh_ground inh_power FILLCAP16A10TR
xpcap_230 inh_ground inh_power FILLCAP16A10TR
xpcap_229 inh_ground inh_power FILLCAP16A10TR
xpcap_228 inh_ground inh_power FILLCAP16A10TR
xpcap_227 inh_ground inh_power FILLCAP16A10TR
xpcap_226 inh_ground inh_power FILLCAP16A10TR
xpcap_225 inh_ground inh_power FILLCAP16A10TR
xpcap_224 inh_ground inh_power FILLCAP16A10TR
xpcap_223 inh_ground inh_power FILLCAP16A10TR
xpcap_222 inh_ground inh_power FILLCAP16A10TR
xpcap_221 inh_ground inh_power FILLCAP16A10TR
xpcap_220 inh_ground inh_power FILLCAP16A10TR
xpcap_219 inh_ground inh_power FILLCAP16A10TR
xpcap_218 inh_ground inh_power FILLCAP16A10TR
xpcap_217 inh_ground inh_power FILLCAP16A10TR
xpcap_216 inh_ground inh_power FILLCAP16A10TR
xpcap_215 inh_ground inh_power FILLCAP16A10TR
xpcap_214 inh_ground inh_power FILLCAP16A10TR
xpcap_213 inh_ground inh_power FILLCAP16A10TR
xpcap_212 inh_ground inh_power FILLCAP16A10TR
xpcap_211 inh_ground inh_power FILLCAP16A10TR
xpcap_210 inh_ground inh_power FILLCAP16A10TR
xpcap_209 inh_ground inh_power FILLCAP16A10TR
xpcap_208 inh_ground inh_power FILLCAP16A10TR
xpcap_207 inh_ground inh_power FILLCAP16A10TR
xpcap_206 inh_ground inh_power FILLCAP16A10TR
xpcap_205 inh_ground inh_power FILLCAP16A10TR
xpcap_204 inh_ground inh_power FILLCAP16A10TR
xpcap_203 inh_ground inh_power FILLCAP16A10TR
xpcap_202 inh_ground inh_power FILLCAP16A10TR
xpcap_201 inh_ground inh_power FILLCAP16A10TR
xpcap_200 inh_ground inh_power FILLCAP16A10TR
xpcap_199 inh_ground inh_power FILLCAP16A10TR
xpcap_198 inh_ground inh_power FILLCAP16A10TR
xpcap_197 inh_ground inh_power FILLCAP16A10TR
xpcap_196 inh_ground inh_power FILLCAP16A10TR
xpcap_195 inh_ground inh_power FILLCAP16A10TR
xpcap_194 inh_ground inh_power FILLCAP16A10TR
xpcap_193 inh_ground inh_power FILLCAP16A10TR
xpcap_192 inh_ground inh_power FILLCAP16A10TR
xpcap_191 inh_ground inh_power FILLCAP16A10TR
xpcap_190 inh_ground inh_power FILLCAP16A10TR
xpcap_189 inh_ground inh_power FILLCAP16A10TR
xpcap_188 inh_ground inh_power FILLCAP16A10TR
xpcap_187 inh_ground inh_power FILLCAP16A10TR
xpcap_186 inh_ground inh_power FILLCAP16A10TR
xpcap_185 inh_ground inh_power FILLCAP16A10TR
xpcap_184 inh_ground inh_power FILLCAP16A10TR
xpcap_183 inh_ground inh_power FILLCAP16A10TR
xpcap_182 inh_ground inh_power FILLCAP16A10TR
xpcap_181 inh_ground inh_power FILLCAP16A10TR
xpcap_180 inh_ground inh_power FILLCAP16A10TR
xpcap_179 inh_ground inh_power FILLCAP16A10TR
xpcap_178 inh_ground inh_power FILLCAP16A10TR
xpcap_177 inh_ground inh_power FILLCAP16A10TR
xpcap_176 inh_ground inh_power FILLCAP16A10TR
xpcap_175 inh_ground inh_power FILLCAP16A10TR
xpcap_174 inh_ground inh_power FILLCAP16A10TR
xpcap_173 inh_ground inh_power FILLCAP16A10TR
xpcap_172 inh_ground inh_power FILLCAP16A10TR
xpcap_171 inh_ground inh_power FILLCAP16A10TR
xpcap_170 inh_ground inh_power FILLCAP16A10TR
xpcap_169 inh_ground inh_power FILLCAP16A10TR
xpcap_168 inh_ground inh_power FILLCAP16A10TR
xpcap_167 inh_ground inh_power FILLCAP16A10TR
xpcap_166 inh_ground inh_power FILLCAP16A10TR
xpcap_165 inh_ground inh_power FILLCAP16A10TR
xpcap_164 inh_ground inh_power FILLCAP16A10TR
xpcap_163 inh_ground inh_power FILLCAP16A10TR
xpcap_162 inh_ground inh_power FILLCAP16A10TR
xpcap_161 inh_ground inh_power FILLCAP16A10TR
xpcap_160 inh_ground inh_power FILLCAP16A10TR
xpcap_159 inh_ground inh_power FILLCAP16A10TR
xpcap_158 inh_ground inh_power FILLCAP16A10TR
xpcap_157 inh_ground inh_power FILLCAP16A10TR
xpcap_156 inh_ground inh_power FILLCAP16A10TR
xpcap_155 inh_ground inh_power FILLCAP16A10TR
xpcap_154 inh_ground inh_power FILLCAP16A10TR
xpcap_153 inh_ground inh_power FILLCAP16A10TR
xpcap_152 inh_ground inh_power FILLCAP16A10TR
xpcap_151 inh_ground inh_power FILLCAP16A10TR
xpcap_150 inh_ground inh_power FILLCAP16A10TR
xpcap_149 inh_ground inh_power FILLCAP16A10TR
xpcap_148 inh_ground inh_power FILLCAP16A10TR
xpcap_147 inh_ground inh_power FILLCAP16A10TR
xpcap_146 inh_ground inh_power FILLCAP16A10TR
xpcap_145 inh_ground inh_power FILLCAP16A10TR
xpcap_144 inh_ground inh_power FILLCAP16A10TR
xpcap_143 inh_ground inh_power FILLCAP16A10TR
xpcap_142 inh_ground inh_power FILLCAP16A10TR
xpcap_141 inh_ground inh_power FILLCAP16A10TR
xpcap_140 inh_ground inh_power FILLCAP16A10TR
xpcap_139 inh_ground inh_power FILLCAP16A10TR
xpcap_138 inh_ground inh_power FILLCAP16A10TR
xpcap_137 inh_ground inh_power FILLCAP16A10TR
xpcap_136 inh_ground inh_power FILLCAP16A10TR
xpcap_135 inh_ground inh_power FILLCAP16A10TR
xpcap_134 inh_ground inh_power FILLCAP16A10TR
xpcap_133 inh_ground inh_power FILLCAP16A10TR
xpcap_132 inh_ground inh_power FILLCAP16A10TR
xpcap_131 inh_ground inh_power FILLCAP16A10TR
xpcap_130 inh_ground inh_power FILLCAP16A10TR
xpcap_129 inh_ground inh_power FILLCAP16A10TR
xpcap_128 inh_ground inh_power FILLCAP16A10TR
xpcap_127 inh_ground inh_power FILLCAP16A10TR
xpcap_126 inh_ground inh_power FILLCAP16A10TR
xpcap_125 inh_ground inh_power FILLCAP16A10TR
xpcap_124 inh_ground inh_power FILLCAP16A10TR
xpcap_123 inh_ground inh_power FILLCAP16A10TR
xpcap_122 inh_ground inh_power FILLCAP16A10TR
xpcap_121 inh_ground inh_power FILLCAP16A10TR
xpcap_120 inh_ground inh_power FILLCAP16A10TR
xpcap_119 inh_ground inh_power FILLCAP16A10TR
xpcap_118 inh_ground inh_power FILLCAP16A10TR
xpcap_117 inh_ground inh_power FILLCAP16A10TR
xpcap_116 inh_ground inh_power FILLCAP16A10TR
xpcap_115 inh_ground inh_power FILLCAP16A10TR
xpcap_114 inh_ground inh_power FILLCAP16A10TR
xpcap_113 inh_ground inh_power FILLCAP16A10TR
xpcap_112 inh_ground inh_power FILLCAP16A10TR
xpcap_111 inh_ground inh_power FILLCAP16A10TR
xpcap_110 inh_ground inh_power FILLCAP16A10TR
xpcap_109 inh_ground inh_power FILLCAP16A10TR
xpcap_108 inh_ground inh_power FILLCAP16A10TR
xpcap_107 inh_ground inh_power FILLCAP16A10TR
xpcap_106 inh_ground inh_power FILLCAP16A10TR
xpcap_105 inh_ground inh_power FILLCAP16A10TR
xpcap_104 inh_ground inh_power FILLCAP16A10TR
xpcap_103 inh_ground inh_power FILLCAP16A10TR
xpcap_102 inh_ground inh_power FILLCAP16A10TR
xpcap_101 inh_ground inh_power FILLCAP16A10TR
xpcap_100 inh_ground inh_power FILLCAP16A10TR
xpcap_99 inh_ground inh_power FILLCAP16A10TR
xpcap_98 inh_ground inh_power FILLCAP16A10TR
xpcap_97 inh_ground inh_power FILLCAP16A10TR
xpcap_96 inh_ground inh_power FILLCAP16A10TR
xpcap_95 inh_ground inh_power FILLCAP16A10TR
xpcap_94 inh_ground inh_power FILLCAP16A10TR
xpcap_93 inh_ground inh_power FILLCAP16A10TR
xpcap_92 inh_ground inh_power FILLCAP16A10TR
xpcap_91 inh_ground inh_power FILLCAP16A10TR
xpcap_90 inh_ground inh_power FILLCAP16A10TR
xpcap_89 inh_ground inh_power FILLCAP16A10TR
xpcap_88 inh_ground inh_power FILLCAP16A10TR
xpcap_87 inh_ground inh_power FILLCAP16A10TR
xpcap_86 inh_ground inh_power FILLCAP16A10TR
xpcap_85 inh_ground inh_power FILLCAP16A10TR
xpcap_84 inh_ground inh_power FILLCAP16A10TR
xpcap_83 inh_ground inh_power FILLCAP16A10TR
xpcap_82 inh_ground inh_power FILLCAP16A10TR
xpcap_81 inh_ground inh_power FILLCAP16A10TR
xpcap_80 inh_ground inh_power FILLCAP16A10TR
xpcap_79 inh_ground inh_power FILLCAP16A10TR
xpcap_78 inh_ground inh_power FILLCAP16A10TR
xpcap_77 inh_ground inh_power FILLCAP16A10TR
xpcap_76 inh_ground inh_power FILLCAP16A10TR
xpcap_75 inh_ground inh_power FILLCAP16A10TR
xpcap_74 inh_ground inh_power FILLCAP16A10TR
xpcap_73 inh_ground inh_power FILLCAP16A10TR
xpcap_72 inh_ground inh_power FILLCAP16A10TR
xpcap_71 inh_ground inh_power FILLCAP16A10TR
xpcap_70 inh_ground inh_power FILLCAP16A10TR
xpcap_69 inh_ground inh_power FILLCAP16A10TR
xpcap_68 inh_ground inh_power FILLCAP16A10TR
xpcap_67 inh_ground inh_power FILLCAP16A10TR
xpcap_66 inh_ground inh_power FILLCAP16A10TR
xpcap_65 inh_ground inh_power FILLCAP16A10TR
xpcap_64 inh_ground inh_power FILLCAP16A10TR
xpcap_63 inh_ground inh_power FILLCAP16A10TR
xpcap_62 inh_ground inh_power FILLCAP16A10TR
xpcap_61 inh_ground inh_power FILLCAP16A10TR
xpcap_60 inh_ground inh_power FILLCAP16A10TR
xpcap_59 inh_ground inh_power FILLCAP16A10TR
xpcap_58 inh_ground inh_power FILLCAP16A10TR
xpcap_57 inh_ground inh_power FILLCAP16A10TR
xpcap_56 inh_ground inh_power FILLCAP16A10TR
xpcap_55 inh_ground inh_power FILLCAP16A10TR
xpcap_54 inh_ground inh_power FILLCAP16A10TR
xpcap_53 inh_ground inh_power FILLCAP16A10TR
xpcap_52 inh_ground inh_power FILLCAP16A10TR
xpcap_51 inh_ground inh_power FILLCAP16A10TR
xpcap_50 inh_ground inh_power FILLCAP16A10TR
xpcap_49 inh_ground inh_power FILLCAP16A10TR
xpcap_48 inh_ground inh_power FILLCAP16A10TR
xpcap_47 inh_ground inh_power FILLCAP16A10TR
xpcap_46 inh_ground inh_power FILLCAP16A10TR
xpcap_45 inh_ground inh_power FILLCAP16A10TR
xpcap_44 inh_ground inh_power FILLCAP16A10TR
xpcap_43 inh_ground inh_power FILLCAP16A10TR
xpcap_42 inh_ground inh_power FILLCAP16A10TR
xpcap_41 inh_ground inh_power FILLCAP16A10TR
xpcap_40 inh_ground inh_power FILLCAP16A10TR
xpcap_39 inh_ground inh_power FILLCAP16A10TR
xpcap_38 inh_ground inh_power FILLCAP16A10TR
xpcap_37 inh_ground inh_power FILLCAP16A10TR
xpcap_36 inh_ground inh_power FILLCAP16A10TR
xpcap_35 inh_ground inh_power FILLCAP16A10TR
xpcap_34 inh_ground inh_power FILLCAP16A10TR
xpcap_33 inh_ground inh_power FILLCAP16A10TR
xpcap_32 inh_ground inh_power FILLCAP16A10TR
xpcap_31 inh_ground inh_power FILLCAP16A10TR
xpcap_30 inh_ground inh_power FILLCAP16A10TR
xpcap_29 inh_ground inh_power FILLCAP16A10TR
xpcap_28 inh_ground inh_power FILLCAP16A10TR
xpcap_27 inh_ground inh_power FILLCAP16A10TR
xpcap_26 inh_ground inh_power FILLCAP16A10TR
xpcap_25 inh_ground inh_power FILLCAP16A10TR
xpcap_24 inh_ground inh_power FILLCAP16A10TR
xpcap_23 inh_ground inh_power FILLCAP16A10TR
xpcap_22 inh_ground inh_power FILLCAP16A10TR
xpcap_21 inh_ground inh_power FILLCAP16A10TR
xpcap_20 inh_ground inh_power FILLCAP16A10TR
xpcap_19 inh_ground inh_power FILLCAP16A10TR
xpcap_18 inh_ground inh_power FILLCAP16A10TR
xpcap_17 inh_ground inh_power FILLCAP16A10TR
xpcap_16 inh_ground inh_power FILLCAP16A10TR
xpcap_15 inh_ground inh_power FILLCAP16A10TR
xpcap_14 inh_ground inh_power FILLCAP16A10TR
xpcap_13 inh_ground inh_power FILLCAP16A10TR
xpcap_12 inh_ground inh_power FILLCAP16A10TR
xpcap_11 inh_ground inh_power FILLCAP16A10TR
xpcap_10 inh_ground inh_power FILLCAP16A10TR
xpcap_9 inh_ground inh_power FILLCAP16A10TR
xpcap_8 inh_ground inh_power FILLCAP16A10TR
xpcap_7 inh_ground inh_power FILLCAP16A10TR
xpcap_6 inh_ground inh_power FILLCAP16A10TR
xpcap_5 inh_ground inh_power FILLCAP16A10TR
xpcap_4 inh_ground inh_power FILLCAP16A10TR
xpcap_3 inh_ground inh_power FILLCAP16A10TR
xpcap_2 inh_ground inh_power FILLCAP16A10TR
xpcap_1 inh_ground inh_power FILLCAP16A10TR
xfill_t_3_201 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_196 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_195 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_193 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_185 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_178 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_177 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_169 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_166 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_138 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_132 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_125 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_123 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_109 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_100 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_92 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_90 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_87 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_77 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_72 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_62 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_58 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_55 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_306 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_293 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_267 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_239 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_229 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_227 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_223 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_220 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_214 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_211 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_202 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_192 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_191 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_187 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_169 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_163 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_134 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_122 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_111 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_96 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_74 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_69 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_58 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_31 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_27 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_23 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_4 inh_ground inh_power FILLCAP4A10TR
xfill_t_2_1 inh_ground inh_power FILLCAP4A10TR
xfill_t_3_52 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_50 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_48 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_46 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_44 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_42 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_40 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_38 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_36 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_34 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_32 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_30 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_28 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_26 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_24 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_22 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_16 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_14 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_12 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_10 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_8 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_6 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_4 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_2 inh_ground inh_power FILLCAP32A10TR
xfill_t_2_242 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_104 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_102 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_100 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_98 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_96 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_94 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_92 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_90 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_88 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_86 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_84 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_82 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_80 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_78 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_76 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_74 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_72 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_70 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_68 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_66 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_64 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_62 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_60 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_58 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_56 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_54 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_52 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_50 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_48 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_46 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_44 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_42 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_40 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_38 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_36 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_34 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_32 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_30 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_28 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_26 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_24 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_22 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_20 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_18 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_16 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_14 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_12 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_10 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_8 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_6 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_1 inh_ground inh_power FILLCAP32A10TR
xfill_t_3_200 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_187 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_181 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_170 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_147 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_124 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_108 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_89 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_73 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_63 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_18 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_298 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_295 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_294 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_289 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_283 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_282 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_270 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_269 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_268 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_266 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_221 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_212 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_203 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_193 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_186 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_175 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_173 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_170 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_144 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_82 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_79 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_71 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_46 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_30 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_29 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_28 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_6 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_4 inh_ground inh_power FILLCAP3A10TR
xfill_t_2_2 inh_ground inh_power FILLCAP3A10TR
xfill_t_3_148 inh_ground inh_power FILLCAP8A10TR
xfill_t_3_117 inh_ground inh_power FILLCAP8A10TR
xfill_t_3_64 inh_ground inh_power FILLCAP8A10TR
xfill_t_3_60 inh_ground inh_power FILLCAP8A10TR
xfill_t_3_20 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_210 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_201 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_167 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_161 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_140 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_102 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_100 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_99 inh_ground inh_power FILLCAP8A10TR
xfill_t_2_56 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_3 inh_ground inh_power FILLCAP8A10TR
xfill_t_3_51 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_47 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_43 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_39 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_35 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_31 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_27 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_23 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_17 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_13 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_9 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_5 inh_ground inh_power FILLCAP64A10TR
xfill_t_3_1 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_101 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_97 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_93 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_89 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_85 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_81 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_77 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_73 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_69 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_65 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_61 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_57 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_53 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_49 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_45 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_41 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_37 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_33 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_29 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_25 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_21 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_17 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_13 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_9 inh_ground inh_power FILLCAP64A10TR
xu86 comp_result n74 inh_ground inh_power INVX1MA10TR
xu87 sar_control0_n90 n99 inh_ground inh_power INVX1MA10TR
xu90 sar_control0_n106 n79 inh_ground inh_power INVX1MA10TR
xu91 sar_control0_n117 n76 inh_ground inh_power INVX1MA10TR
xu96 sar_control0_n73 n93 inh_ground inh_power INVX1MA10TR
xu101 sar_control0_n105 n81 inh_ground inh_power INVX1MA10TR
xu103 sar_control0_n129 n78 inh_ground inh_power INVX1MA10TR
xu107 sar_control0_n113 n80 inh_ground inh_power INVX1MA10TR
xu109 sar_control0_n97 n94 inh_ground inh_power INVX1MA10TR
xu110 sar_control0_n96 n95 inh_ground inh_power INVX1MA10TR
xu112 sar_control0_n87 n75 inh_ground inh_power INVX1MA10TR
xu117 sar_control0_n86 n82 inh_ground inh_power INVX1MA10TR
xu120 sar_control0_n76 n101 inh_ground inh_power INVX1MA10TR
xu123 sar_control0_n83 n102 inh_ground inh_power INVX1MA10TR
xu125 eoc_n n92 inh_ground inh_power INVX1MA10TR
xu131 cp<0> n90 inh_ground inh_power INVX1MA10TR
xu133 sar_control0_n75 n100 inh_ground inh_power INVX1MA10TR
xu134 sar_control0_n72 n97 inh_ground inh_power INVX1MA10TR
xu135 sar_control0_n88 n96 inh_ground inh_power INVX1MA10TR
xu139 sar_control0_n89 n98 inh_ground inh_power INVX1MA10TR
xu144 sar_control0_n122 n77 inh_ground inh_power INVX1MA10TR
xu154 sar_control0_n119 n83 inh_ground inh_power INVX1MA10TR
xu157 sar_control0_n102 n84 inh_ground inh_power INVX1MA10TR
xu166 fe_phn28_sar_control0_off_bit n91 inh_ground inh_power INVX1MA10TR
xu167 real_calib_en n72 inh_ground inh_power INVX1MA10TR
xu192 fe_phn30_sar_control0_c_state_2 n103 inh_ground inh_power INVX1MA10TR
xu194 fe_phn77_sar_control0_c_state_1 n104 inh_ground inh_power INVX1MA10TR
xu195 sar_control0_n101 n89 inh_ground inh_power INVX1MA10TR
xu196 sar_control0_n118 n87 inh_ground inh_power INVX1MA10TR
xu222 firm_en n73 inh_ground inh_power INVX1MA10TR
xu232 cn<1> n88 inh_ground inh_power INVX1MA10TR
xu236 fe_phn26_n107 n55 inh_ground inh_power INVX1MA10TR
xu240 cn<2> n86 inh_ground inh_power INVX1MA10TR
xu243 rst n71 inh_ground inh_power INVX1MA10TR
xu93 sar_control0_n98 sar_control0_n80 sar_control0_dac_switches_top_next_0<0> inh_ground inh_power NAND2X1BA10TR
xu113 fe_phn45_sar_control0_n71 n97 sar_control0_n94 inh_ground inh_power NAND2X1BA10TR
xu116 sar_control0_n86 n91 sar_control0_n102 inh_ground inh_power NAND2X1BA10TR
xu136 sar_control0_n52 sar_control0_n90 sar_control0_dac_switches_top_next_0<1> inh_ground inh_power NAND2X1BA10TR
xu140 sar_control0_n147 sar_control0_n146 sar_control0_n52 inh_ground inh_power NAND2X1BA10TR
xu142 sar_control0_n133 n102 sar_control0_n105 inh_ground inh_power NAND2X1BA10TR
xu143 sar_control0_n147 sar_control0_n144 sar_control0_n92 inh_ground inh_power NAND2X1BA10TR
xu145 sar_control0_n147 sar_control0_n143 sar_control0_n97 inh_ground inh_power NAND2X1BA10TR
xu146 sar_control0_n147 sar_control0_n134 sar_control0_n96 inh_ground inh_power NAND2X1BA10TR
xu148 sar_control0_n145 sar_control0_n146 sar_control0_n81 inh_ground inh_power NAND2X1BA10TR
xu150 sar_control0_n145 sar_control0_n144 sar_control0_n93 inh_ground inh_power NAND2X1BA10TR
xu151 sar_control0_n145 sar_control0_n143 sar_control0_n88 inh_ground inh_power NAND2X1BA10TR
xu152 sar_control0_n131 sar_control0_n132 sar_control0_cn_next<0> inh_ground inh_power NAND2X1BA10TR
xu155 sar_control0_n115 sar_control0_n116 sar_control0_cp_next<0> inh_ground inh_power NAND2X1BA10TR
xu159 sar_control0_n134 sar_control0_n142 sar_control0_n89 inh_ground inh_power NAND2X1BA10TR
xu160 sar_control0_n86 fe_phn28_sar_control0_off_bit sar_control0_n119 inh_ground inh_power NAND2X1BA10TR
xu168 sar_control0_n134 sar_control0_n135 sar_control0_n83 inh_ground inh_power NAND2X1BA10TR
xu180 sar_control0_n135 sar_control0_n143 sar_control0_n82 inh_ground inh_power NAND2X1BA10TR
xu184 sar_control0_n142 sar_control0_n143 sar_control0_n76 inh_ground inh_power NAND2X1BA10TR
xu185 sar_control0_n144 sar_control0_n142 sar_control0_n77 inh_ground inh_power NAND2X1BA10TR
xu186 sar_control0_n146 sar_control0_n142 sar_control0_n75 inh_ground inh_power NAND2X1BA10TR
xu187 sar_control0_n145 sar_control0_n134 sar_control0_n72 inh_ground inh_power NAND2X1BA10TR
xu188 sar_control0_n135 sar_control0_n144 sar_control0_n91 inh_ground inh_power NAND2X1BA10TR
xu211 n52 n91 sar_control0_n108 inh_ground inh_power NAND2X1BA10TR
xu242 n4 fe_phn64_n1 n11 inh_ground inh_power NAND2X1BA10TR
xu88 sar_control0_n193 n95 sar_control0_n197 inh_ground inh_power NOR2BX1MA10TR
xu89 sar_control0_n190 n94 sar_control0_n193 inh_ground inh_power NOR2BX1MA10TR
xu92 sar_control0_n94 n96 sar_control0_n95 inh_ground inh_power NOR2BX1MA10TR
xu164 sar_control0_n137 sar_control0_n82 sar_control0_n85 inh_ground inh_power NOR2BX1MA10TR
xu193 fe_phn32_sar_control0_c_state_0 n104 sar_control0_n146 inh_ground inh_power NOR2BX1MA10TR
xu209 fe_phn32_sar_control0_c_state_0 fe_phn77_sar_control0_c_state_1 sar_control0_n143 inh_ground inh_power NOR2BX1MA10TR
xu224 fe_phn31_sar_control0_c_state_3 fe_phn30_sar_control0_c_state_2 sar_control0_n142 inh_ground inh_power NOR2BX1MA10TR
xu234 fe_phn31_sar_control0_c_state_3 n103 sar_control0_n135 inh_ground inh_power NOR2BX1MA10TR
xu241 fe_phn37_dead_calib_counter_1 n85 n4 inh_ground inh_power NOR2BX1MA10TR
xu98 sar_control0_n202 sar_control0_n93 sar_control0_n208 inh_ground inh_power AND2X1MA10TR
xu99 sar_control0_n197 sar_control0_n81 sar_control0_n202 inh_ground inh_power AND2X1MA10TR
xu100 sar_control0_n92 sar_control0_n52 sar_control0_n190 inh_ground inh_power AND2X1MA10TR
xu238 fe_phn26_n107 fe_phn70_sar_control0_cn_store_0 sar_control0_add_75_carry<1> inh_ground inh_power AND2X1MA10TR
xu239 cp<0> fe_phn72_sar_control0_cp_store_0 sar_control0_add_76_carry<1> inh_ground inh_power AND2X1MA10TR
xu82 n103 fe_phn31_sar_control0_c_state_3 sar_control0_n147 inh_ground inh_power NOR2X1AA10TR
xu83 n104 fe_phn32_sar_control0_c_state_0 sar_control0_n144 inh_ground inh_power NOR2X1AA10TR
xu84 fe_phn32_sar_control0_c_state_0 fe_phn77_sar_control0_c_state_1 sar_control0_n134 inh_ground inh_power NOR2X1AA10TR
xu85 fe_phn30_sar_control0_c_state_2 fe_phn31_sar_control0_c_state_3 sar_control0_n145 inh_ground inh_power NOR2X1AA10TR
xu95 sar_control0_n100 n100 sar_control0_n90 inh_ground inh_power NOR2X1AA10TR
xu102 sar_control0_n87 n81 sar_control0_n117 inh_ground inh_power NOR2X1AA10TR
xu147 sar_control0_n137 sar_control0_n82 sar_control0_n87 inh_ground inh_power NOR2X1AA10TR
xu158 fe_phn35_n54 real_calib_en sar_control0_n71 inh_ground inh_power NOR2X1AA10TR
xu162 sar_control0_n83 sar_control0_n133 sar_control0_n86 inh_ground inh_power NOR2X1AA10TR
xu217 fe_phn28_sar_control0_off_bit cp<3> sar_control0_n140 inh_ground inh_power NOR2X1AA10TR
xu226 n94 n95 sar_control0_n99 inh_ground inh_power NOR2X1AA10TR
xu237 sar_control0_n88 comp_result sar_control0_dac_switches_top_next_7<0> inh_ground inh_power NOR2X1AA10TR
xu106 sar_control0_n117 n91 sar_control0_n100 sar_control0_n114 inh_ground inh_power OAI21X1MA10TR
xu141 fe_phn28_sar_control0_off_bit sar_control0_n117 sar_control0_n100 sar_control0_n130 inh_ground inh_power OAI21X1MA10TR
xu228 comp_result sar_control0_n97 sar_control0_n98 sar_control0_dac_switches_top_next_3<0> inh_ground inh_power OAI21X1MA10TR
xu230 comp_result sar_control0_n81 sar_control0_n95 sar_control0_dac_switches_top_next_5<0> inh_ground inh_power OAI21X1MA10TR
xu233 comp_result sar_control0_n93 sar_control0_n94 sar_control0_dac_switches_top_next_6<0> inh_ground inh_power OAI21X1MA10TR
xu121 sar_control0_n76 sar_control0_n75 sar_control0_n77 sar_control0_n78 sar_control0_n_state<3> inh_ground inh_power NAND4X1AA10TR
xu127 sar_control0_n83 sar_control0_n82 sar_control0_n77 sar_control0_n76 sar_control0_n100 inh_ground inh_power NAND4X1AA10TR
xu128 sar_control0_n208 sar_control0_n74 sar_control0_n88 sar_control0_n72 sar_control0_n73 inh_ground inh_power NAND4X1AA10TR
xu132 sar_control0_n80 sar_control0_n79 fe_phn88_sar_control0_n81 sar_control0_n75 sar_control0_n_state<2> inh_ground inh_power NAND4X1AA10TR
xu215 n90 n62 sar_control0_n140 n52 sar_control0_n139 inh_ground inh_power NAND4X1AA10TR
xu216 fe_phn28_sar_control0_off_bit n55 sar_control0_n141 n88 sar_control0_n138 inh_ground inh_power NAND4X1AA10TR
xu231 cp<2> fe_phn27_n109 cp<0> n91 sar_control0_n101 inh_ground inh_power NAND4X1AA10TR
xu165 n74 sar_control0_n88 sar_control0_n94 sar_control0_n90 sar_control0_dac_switches_top_next_7<1> inh_ground inh_power OAI211X1MA10TR
xu174 n74 sar_control0_n93 sar_control0_n88 sar_control0_n90 sar_control0_dac_switches_top_next_6<1> inh_ground inh_power OAI211X1MA10TR
xu175 n74 sar_control0_n52 sar_control0_n92 sar_control0_n90 sar_control0_dac_switches_top_next_1<1> inh_ground inh_power OAI211X1MA10TR
xu176 n74 sar_control0_n92 sar_control0_n97 sar_control0_n90 sar_control0_dac_switches_top_next_2<1> inh_ground inh_power OAI211X1MA10TR
xu177 n74 sar_control0_n81 sar_control0_n93 sar_control0_n90 sar_control0_dac_switches_top_next_5<1> inh_ground inh_power OAI211X1MA10TR
xu178 n74 sar_control0_n96 sar_control0_n81 sar_control0_n90 sar_control0_dac_switches_top_next_4<1> inh_ground inh_power OAI211X1MA10TR
xu179 n74 sar_control0_n97 sar_control0_n96 sar_control0_n90 sar_control0_dac_switches_top_next_3<1> inh_ground inh_power OAI211X1MA10TR
xu199 sar_control0_n118 sar_control0_n83 sar_control0_n119 sar_control0_n120 sar_control0_cn_next<3> inh_ground inh_power OAI211X1MA10TR
xu201 n86 n75 sar_control0_n105 sar_control0_n122 sar_control0_n121 inh_ground inh_power OAI211X1MA10TR
xu202 sar_control0_n101 sar_control0_n83 sar_control0_n102 sar_control0_n103 sar_control0_cp_next<3> inh_ground inh_power OAI211X1MA10TR
xu204 n52 n75 sar_control0_n105 sar_control0_n106 sar_control0_n104 inh_ground inh_power OAI211X1MA10TR
xu206 sar_control0_n125 sar_control0_n126 n86 fe_phn28_sar_control0_off_bit sar_control0_n123 inh_ground inh_power OAI211X1MA10TR
xu210 sar_control0_n107 sar_control0_n108 sar_control0_n102 sar_control0_n109 sar_control0_cp_next<2> inh_ground inh_power OAI211X1MA10TR
xu218 sar_control0_n127 n91 sar_control0_n119 sar_control0_n128 sar_control0_cn_next<1> inh_ground inh_power OAI211X1MA10TR
xu225 comp_result sar_control0_n52 sar_control0_n98 sar_control0_n99 sar_control0_dac_switches_top_next_1<0> inh_ground inh_power OAI211X1MA10TR
xu227 comp_result sar_control0_n92 sar_control0_n96 sar_control0_n98 sar_control0_dac_switches_top_next_2<0> inh_ground inh_power OAI211X1MA10TR
xu229 comp_result sar_control0_n96 sar_control0_n93 sar_control0_n95 sar_control0_dac_switches_top_next_4<0> inh_ground inh_power OAI211X1MA10TR
xu223 fe_phn78_dead_calib_en n73 firm_en calib_en real_calib_en inh_ground inh_power AO22X1MA10TR
xu111 cp<0> fe_phn27_n109 n75 sar_control0_n110 inh_ground inh_power NOR3X1AA10TR
xu208 sar_control0_n83 n55 n88 sar_control0_n125 inh_ground inh_power NOR3X1AA10TR
xu221 fe_phn26_n107 cn<1> n75 sar_control0_n126 inh_ground inh_power NOR3X1AA10TR
xu200 sar_control0_cn_avg<3> sar_control0_n85 cn<3> sar_control0_n121 sar_control0_n120 inh_ground inh_power AOI22X1MA10TR
xu203 sar_control0_cp_avg<3> sar_control0_n85 cp<3> sar_control0_n104 sar_control0_n103 inh_ground inh_power AOI22X1MA10TR
xu207 sar_control0_cn_avg<2> sar_control0_n85 cn<2> n77 sar_control0_n124 inh_ground inh_power AOI22X1MA10TR
xu213 sar_control0_cp_avg<2> sar_control0_n85 cp<2> n79 sar_control0_n109 inh_ground inh_power AOI22X1MA10TR
xu220 sar_control0_cn_avg<1> sar_control0_n85 cn<1> n78 sar_control0_n128 inh_ground inh_power AOI22X1MA10TR
xu149 cp<0> n62 n102 sar_control0_n110 sar_control0_n111 inh_ground inh_power AOI31X1MA10TR
xu153 n76 n55 fe_phn28_sar_control0_off_bit n83 sar_control0_n132 inh_ground inh_power AOI31X1MA10TR
xu156 n90 n91 n76 n84 sar_control0_n116 inh_ground inh_power AOI31X1MA10TR
xu212 cp<1> cp<0> n102 sar_control0_n110 sar_control0_n107 inh_ground inh_power AOI31X1MA10TR
xu219 fe_phn26_n107 n88 n102 sar_control0_n126 sar_control0_n127 inh_ground inh_power AOI31X1MA10TR
xu138 sar_control0_n92 sar_control0_n77 sar_control0_n93 sar_control0_n84 inh_ground inh_power NAND3X1AA10TR
xu205 sar_control0_n123 sar_control0_n119 sar_control0_n124 sar_control0_cn_next<2> inh_ground inh_power NAND3X1AA10TR
xu214 sar_control0_n138 sar_control0_n139 sar_control0_n136 sar_control0_n137 inh_ground inh_power NAND3X1AA10TR
xu198 fe_phn28_sar_control0_off_bit comp_result sar_control0_n136 inh_ground inh_power XOR2X1MA10TR
xu104 n55 n81 fe_phn26_n107 sar_control0_n87 sar_control0_n130 sar_control0_n129 inh_ground inh_power AOI221X1MA10TR
xu105 n62 n81 cp<1> sar_control0_n87 n80 sar_control0_n106 inh_ground inh_power AOI221X1MA10TR
xu108 n90 n81 cp<0> sar_control0_n87 sar_control0_n114 sar_control0_n113 inh_ground inh_power AOI221X1MA10TR
xu197 n88 n81 cn<1> sar_control0_n87 n78 sar_control0_n122 inh_ground inh_power AOI221X1MA10TR
xu181 n100 n91 n74 sar_control0_n75 sar_control0_n148 inh_ground inh_power OAI22X1MA10TR
xu79 n52 cp<2> inh_ground inh_power INVX3MA10TR
xu171 n62 cp<1> inh_ground inh_power INVX3MA10TR
xu172 n55 cn<0> inh_ground inh_power INVX3MA10TR
xu114 sar_control0_n93 sar_control0_n81 sar_control0_n95 sar_control0_n98 inh_ground inh_power AND3X1MA10TR
xu129 sar_control0_n82 sar_control0_n73 sar_control0_n83 sar_control0_n79 inh_ground inh_power AND3X1MA10TR
xu130 sar_control0_n89 sar_control0_n90 sar_control0_n91 sar_control0_n74 inh_ground inh_power AND3X1MA10TR
xu137 sar_control0_n97 sar_control0_n92 sar_control0_n96 sar_control0_n80 inh_ground inh_power AND3X1MA10TR
xu124 n92 sar_control0_n91 sar_control0_n75 sar_control0_n72 sar_control0_n225 inh_ground inh_power AND4X0P7MA10TR
xu126 sar_control0_n225 sar_control0_n82 sar_control0_n77 sar_control0_n76 sar_control0_n229 inh_ground inh_power AND4X0P7MA10TR
xu122 n72 sar_control0_n72 sar_control0_n79 sar_control0_n52 sar_control0_n78 inh_ground inh_power OA211X0P7MA10TR
xu118 n95 sar_control0_n86 sar_control0_n84 n97 n93 sar_control0_n87 sar_control0_n_state<0> inh_ground inh_power OR6X1MA10TR
xu119 n94 n96 sar_control0_n84 n93 sar_control0_n85 n101 sar_control0_n_state<1> inh_ground inh_power OR6X1MA10TR
xu115 sar_control0_dac_switches_top_next_0<0> sar_control0_n52 sar_control0_dummy_switch_top_next_0_ inh_ground inh_power NAND2BX1MA10TR
xu97 sar_control0_n88 sar_control0_n89 sar_control0_n208 eoc_n inh_ground inh_power NAND3X3AA10TR
xu81 cn<2> cn<1> fe_phn26_n107 fe_phn28_sar_control0_off_bit sar_control0_n118 inh_ground inh_power NAND4X0P5MA10TR
xu80 cn<3> cn<2> sar_control0_n141 inh_ground inh_power NOR2X0P5MA10TR
xu28 fe_phn36_dead_calib_counter_0 n85 inh_ground inh_power INVX0P5BA10TR
xu72 fe_phn27_n109 n62 inh_ground inh_power INVX0P5BA10TR
xu78 fe_phn33_n108 n52 inh_ground inh_power INVX0P5BA10TR
xu77 n89 cp<3> n87 cn<3> sar_control0_n136 sar_control0_n133 inh_ground inh_power AOI221X0P5MA10TR
xu11 dead_adc_en n73 adc_en firm_en n54 inh_ground inh_power AOI22X0P5MA10TR
xu64 sar_control0_cp_avg<0> sar_control0_n85 cp<0> sar_control0_n114 sar_control0_n115 inh_ground inh_power AOI22X0P5MA10TR
xu67 sar_control0_cn_avg<0> sar_control0_n85 fe_phn26_n107 sar_control0_n130 sar_control0_n131 inh_ground inh_power AOI22X0P5MA10TR
xu71 sar_control0_cp_avg<1> sar_control0_n85 fe_phn27_n109 n80 sar_control0_n112 inh_ground inh_power AOI22X0P5MA10TR
xu13 fe_phn45_sar_control0_n71 sar_control0_n72 sar_control0_n73 sar_control0_n74 sar_control0_s_c_next inh_ground inh_power OAI211X0P5MA10TR
xu70 fe_phn28_sar_control0_off_bit sar_control0_n111 sar_control0_n102 sar_control0_n112 sar_control0_cp_next<1> inh_ground inh_power OAI211X0P5MA10TR
xu39 fe_phn71_sar_control0_cp_store_1 n82 sar_control0_n86 cp<1> sar_control0_cp_store_next<1> inh_ground inh_power AO22X0P5MA10TR
xu42 fe_phn72_sar_control0_cp_store_0 n82 sar_control0_n86 cp<0> sar_control0_cp_store_next<0> inh_ground inh_power AO22X0P5MA10TR
xu45 fe_phn70_sar_control0_cn_store_0 n82 sar_control0_n86 fe_phn26_n107 sar_control0_cn_store_next<0> inh_ground inh_power AO22X0P5MA10TR
xu49 fe_phn68_sar_control0_cp_store_3 n82 sar_control0_n86 cp<3> sar_control0_cp_store_next<3> inh_ground inh_power AO22X0P5MA10TR
xu53 fe_phn66_sar_control0_cn_store_3 n82 sar_control0_n86 cn<3> sar_control0_cn_store_next<3> inh_ground inh_power AO22X0P5MA10TR
xu55 fe_phn69_sar_control0_cp_store_2 n82 sar_control0_n86 cp<2> sar_control0_cp_store_next<2> inh_ground inh_power AO22X0P5MA10TR
xu59 fe_phn67_sar_control0_cn_store_2 n82 sar_control0_n86 cn<2> sar_control0_cn_store_next<2> inh_ground inh_power AO22X0P5MA10TR
xu61 fe_phn65_sar_control0_cn_store_1 n82 sar_control0_n86 cn<1> sar_control0_cn_store_next<1> inh_ground inh_power AO22X0P5MA10TR
xu37 n4 fe_phn64_n1 fe_phn46_n11 n7 inh_ground inh_power OAI21X0P5MA10TR
xu33 fe_phn37_dead_calib_counter_1 fe_phn36_dead_calib_counter_0 n6 inh_ground inh_power XOR2X0P5MA10TR
xu12 fe_phn35_n54 n72 n97 sar_control0_n231 inh_ground inh_power NAND3X0P5MA10TR
xdead_calib_counter_reg_1_ net94 fe_phn86_n6 dead_calib_counter<1> rst inh_ground inh_power DFFRPQX1MA10TR
xdead_calib_counter_reg_0_ net94 fe_phn85_n85 dead_calib_counter<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdead_calib_en_reg cts_2 fe_phn46_n11 dead_calib_en rst inh_ground inh_power DFFRPQX1MA10TR
xdead_adc_en_reg cts_2 ltiehi_net dead_adc_en rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_off_bit_reg sar_control0_net130 fe_phn84_sar_control0_n148 sar_control0_off_bit rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_c_state_reg_3_ sar_control0_net171 fe_phn81_sar_control0_n_state_3 sar_control0_c_state<3> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_c_state_reg_0_ sar_control0_net171 sar_control0_n_state<0> sar_control0_c_state<0> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_c_state_reg_1_ sar_control0_net171 sar_control0_n_state<1> sar_control0_c_state<1> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_c_state_reg_2_ sar_control0_net171 sar_control0_n_state<2> sar_control0_c_state<2> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_store_reg_1_ sar_control0_net166 fe_phn55_sar_control0_cp_store_next_1 sar_control0_cp_store<1> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_store_reg_0_ sar_control0_net166 fe_phn49_sar_control0_cp_store_next_0 sar_control0_cp_store<0> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_store_reg_0_ sar_control0_net166 fe_phn53_sar_control0_cn_store_next_0 sar_control0_cn_store<0> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_store_reg_3_ sar_control0_net166 fe_phn52_sar_control0_cp_store_next_3 sar_control0_cp_store<3> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_store_reg_3_ sar_control0_net166 fe_phn58_sar_control0_cn_store_next_3 sar_control0_cn_store<3> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_store_reg_2_ sar_control0_net166 fe_phn61_sar_control0_cp_store_next_2 sar_control0_cp_store<2> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_store_reg_2_ sar_control0_net166 fe_phn59_sar_control0_cn_store_next_2 sar_control0_cn_store<2> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_store_reg_1_ sar_control0_net166 fe_phn57_sar_control0_cn_store_next_1 sar_control0_cn_store<1> rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_reg_0_ sar_control0_net161 fe_phn62_sar_control0_cp_next_0 fe_ofn24_cp_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_reg_0_ sar_control0_net161 fe_phn56_sar_control0_cn_next_0 n107 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_reg_1_ sar_control0_net161 fe_phn48_sar_control0_cp_next_1 n109 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_reg_1_ sar_control0_net161 fe_phn50_sar_control0_cn_next_1 fe_ofn22_cn_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cn_reg_2_ sar_control0_net161 fe_phn54_sar_control0_cn_next_2 fe_ofn21_cn_2 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_cp_reg_3_ sar_control0_net161 fe_phn51_sar_control0_cp_next_3 fe_ofn23_cp_3 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_7_reg_1_ sar_control0_net156 sar_control0_dac_switches_top_next_7<0> fe_ofn16_dac_switches_bot_7_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_6_reg_1_ sar_control0_net151 sar_control0_dac_switches_top_next_6<0> fe_ofn14_dac_switches_bot_6_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_0_reg_0_ cts_2 sar_control0_dac_switches_top_next_0<1> fe_ofn3_dac_switches_bot_0_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dummy_switch_bot_reg_0_ cts_2 n99 fe_ofn19_dummy_switch_bot_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_5_reg_1_ sar_control0_net146 sar_control0_dac_switches_top_next_5<0> fe_ofn12_dac_switches_bot_5_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_4_reg_1_ sar_control0_net141 sar_control0_dac_switches_top_next_4<0> fe_ofn10_dac_switches_bot_4_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_6_reg_0_ sar_control0_net151 sar_control0_dac_switches_top_next_6<1> fe_ofn15_dac_switches_bot_6_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_1_reg_0_ cts_2 sar_control0_dac_switches_top_next_1<1> fe_ofn5_dac_switches_bot_1_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_7_reg_0_ sar_control0_net156 sar_control0_dac_switches_top_next_7<1> fe_ofn17_dac_switches_bot_7_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_4_reg_0_ sar_control0_net141 sar_control0_dac_switches_top_next_4<1> fe_ofn11_dac_switches_bot_4_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_2_reg_0_ sar_control0_net130 sar_control0_dac_switches_top_next_2<1> fe_ofn7_dac_switches_bot_2_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_5_reg_0_ sar_control0_net146 sar_control0_dac_switches_top_next_5<1> fe_ofn13_dac_switches_bot_5_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_3_reg_0_ sar_control0_net136 sar_control0_dac_switches_top_next_3<1> fe_ofn9_dac_switches_bot_3_0 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_3_reg_1_ sar_control0_net136 sar_control0_dac_switches_top_next_3<0> fe_ofn8_dac_switches_bot_3_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_1_reg_1_ cts_2 sar_control0_dac_switches_top_next_1<0> fe_ofn4_dac_switches_bot_1_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_2_reg_1_ sar_control0_net130 sar_control0_dac_switches_top_next_2<0> fe_ofn6_dac_switches_bot_2_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_bot_0_reg_1_ cts_2 sar_control0_dac_switches_top_next_0<0> fe_ofn2_dac_switches_bot_0_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dummy_switch_bot_reg_1_ cts_2 sar_control0_dummy_switch_top_next_0_ fe_ofn25_dummy_switch_bot_1 rst inh_ground inh_power DFFRPQX1MA10TR
xsar_control0_dac_switches_top_7_reg_0_ sar_control0_net156 sar_control0_dac_switches_top_next_7<0> dac_switches_top_7<0> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_6_reg_0_ sar_control0_net151 sar_control0_dac_switches_top_next_6<0> dac_switches_top_6<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_6_ adc_regs0_net112 fe_phn41_dac_switches_top_6_0 q<6> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_5_reg_0_ sar_control0_net146 sar_control0_dac_switches_top_next_5<0> dac_switches_top_5<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_5_ adc_regs0_net112 fe_phn40_dac_switches_top_5_0 q<5> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_4_reg_0_ sar_control0_net141 sar_control0_dac_switches_top_next_4<0> dac_switches_top_4<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_4_ adc_regs0_net112 fe_phn79_dac_switches_top_4_0 q<4> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_3_reg_0_ sar_control0_net136 sar_control0_dac_switches_top_next_3<0> dac_switches_top_3<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_3_ adc_regs0_net112 fe_phn80_dac_switches_top_3_0 q<3> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_1_reg_0_ cts_2 sar_control0_dac_switches_top_next_1<0> dac_switches_top_1<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_1_ adc_regs0_net112 fe_phn39_dac_switches_top_1_0 q<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_2_reg_0_ sar_control0_net130 sar_control0_dac_switches_top_next_2<0> dac_switches_top_2<0> rst inh_ground inh_power DFFRPQX2MA10TR
xadc_regs0_q_reg_2_ adc_regs0_net112 fe_phn38_dac_switches_top_2_0 q<2> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_0_reg_1_ cts_2 sar_control0_dac_switches_top_next_0<1> dac_switches_top_0<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dummy_switch_top_reg_1_ cts_2 n99 dummy_switch_top<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_6_reg_1_ sar_control0_net151 sar_control0_dac_switches_top_next_6<1> dac_switches_top_6<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_1_reg_1_ cts_2 sar_control0_dac_switches_top_next_1<1> dac_switches_top_1<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_7_reg_1_ sar_control0_net156 sar_control0_dac_switches_top_next_7<1> dac_switches_top_7<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_4_reg_1_ sar_control0_net141 sar_control0_dac_switches_top_next_4<1> dac_switches_top_4<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_2_reg_1_ sar_control0_net130 sar_control0_dac_switches_top_next_2<1> dac_switches_top_2<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_5_reg_1_ sar_control0_net146 sar_control0_dac_switches_top_next_5<1> dac_switches_top_5<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_3_reg_1_ sar_control0_net136 sar_control0_dac_switches_top_next_3<1> dac_switches_top_3<1> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dac_switches_top_0_reg_0_ cts_2 sar_control0_dac_switches_top_next_0<0> dac_switches_top_0<0> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_dummy_switch_top_reg_0_ cts_2 sar_control0_dummy_switch_top_next_0_ dummy_switch_top<0> rst inh_ground inh_power DFFRPQX2MA10TR
xsar_control0_cp_reg_2_ sar_control0_net161 fe_phn47_sar_control0_cp_next_2 n108 rst inh_ground inh_power DFFRPQX0P5MA10TR
xsar_control0_cn_reg_3_ sar_control0_net161 fe_phn60_sar_control0_cn_next_3 fe_ofn20_cn_3 rst inh_ground inh_power DFFRPQX0P5MA10TR
xadc_regs0_q_reg_0_ adc_regs0_net112 n74 fe_ofn0_q_0 rst inh_ground inh_power DFFRPQX0P5MA10TR
xadc_regs0_q_reg_7_ adc_regs0_net112 fe_phn44_dac_switches_top_7_0 q<7> rst inh_ground inh_power DFFRPQX3MA10TR
xsar_control0_s_c_reg cts_2 sar_control0_s_c_next fe_rn_1 n71 inh_ground inh_power DFFSQX3MA10TR
xsar_control0_add_76_u1_1 fe_phn71_sar_control0_cp_store_1 fe_phn27_n109 sar_control0_add_76_carry<1> sar_control0_add_76_carry<2> sar_control0_cp_avg<0> inh_ground inh_power ADDFX1MA10TR
xsar_control0_add_76_u1_2 fe_phn69_sar_control0_cp_store_2 cp<2> sar_control0_add_76_carry<2> sar_control0_add_76_carry<3> sar_control0_cp_avg<1> inh_ground inh_power ADDFX1MA10TR
xsar_control0_add_76_u1_3 fe_phn68_sar_control0_cp_store_3 cp<3> sar_control0_add_76_carry<3> sar_control0_cp_avg<3> sar_control0_cp_avg<2> inh_ground inh_power ADDFX1MA10TR
xsar_control0_add_75_u1_2 fe_phn67_sar_control0_cn_store_2 cn<2> sar_control0_add_75_carry<2> sar_control0_add_75_carry<3> sar_control0_cn_avg<1> inh_ground inh_power ADDFX1MA10TR
xsar_control0_add_75_u1_1 fe_phn65_sar_control0_cn_store_1 cn<1> sar_control0_add_75_carry<1> sar_control0_add_75_carry<2> sar_control0_cn_avg<0> inh_ground inh_power ADDFX1MA10TR
xsar_control0_add_75_u1_3 fe_phn66_sar_control0_cn_store_3 cn<3> sar_control0_add_75_carry<3> sar_control0_cn_avg<3> sar_control0_cn_avg<2> inh_ground inh_power ADDFX1MA10TR
xdead_calib_counter_reg_2_ net94 fe_phn63_n7 n1 rst inh_ground inh_power DFFRPQNX1MA10TR
xadc_regs0_clk_gate_q_reg clk n98 adc_regs0_net112 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
xsar_control0_clk_gate_dac_switches_top_2_reg clk sar_control0_n52 sar_control0_net130 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
xsar_control0_clk_gate_dac_switches_top_3_reg clk sar_control0_n190 sar_control0_net136 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
xsar_control0_clk_gate_dac_switches_top_4_reg clk sar_control0_n193 sar_control0_net141 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
xsar_control0_clk_gate_dac_switches_top_5_reg clk sar_control0_n197 sar_control0_net146 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
xsar_control0_clk_gate_dac_switches_top_6_reg clk sar_control0_n202 sar_control0_net151 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
xsar_control0_clk_gate_dac_switches_top_7_reg clk sar_control0_n208 sar_control0_net156 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
xsar_control0_clk_gate_cn_reg clk sar_control0_n225 sar_control0_net161 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
xsar_control0_clk_gate_cn_store_reg clk sar_control0_n229 sar_control0_net166 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
xsar_control0_clk_gate_c_state_reg clk sar_control0_n231 sar_control0_net171 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
xclk_gate_dead_calib_counter_reg clk fe_phn46_n11 net94 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
xfe_ofc1_s_c s_c s_c1 inh_ground inh_power BUFX2MA10TR
xfe_ofc0_q_0 fe_ofn0_q_0 q<0> inh_ground inh_power BUFX2MA10TR
xcts_ccl_a_buf_00001 clk cts_2 inh_ground inh_power BUFX3MA10TR
xfe_ofc25_dummy_switch_bot_1 fe_ofn25_dummy_switch_bot_1 dummy_switch_bot<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc24_cp_0 fe_ofn24_cp_0 cp<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc23_cp_3 fe_ofn23_cp_3 cp<3> inh_ground inh_power BUFX3MA10TR
xfe_ofc22_cn_1 fe_ofn22_cn_1 cn<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc21_cn_2 fe_ofn21_cn_2 cn<2> inh_ground inh_power BUFX3MA10TR
xfe_ofc20_cn_3 fe_ofn20_cn_3 cn<3> inh_ground inh_power BUFX3MA10TR
xfe_ofc19_dummy_switch_bot_0 fe_ofn19_dummy_switch_bot_0 dummy_switch_bot<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc17_dac_switches_bot_7_0 fe_ofn17_dac_switches_bot_7_0 dac_switches_bot_7<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc16_dac_switches_bot_7_1 fe_ofn16_dac_switches_bot_7_1 dac_switches_bot_7<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc15_dac_switches_bot_6_0 fe_ofn15_dac_switches_bot_6_0 dac_switches_bot_6<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc14_dac_switches_bot_6_1 fe_ofn14_dac_switches_bot_6_1 dac_switches_bot_6<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc13_dac_switches_bot_5_0 fe_ofn13_dac_switches_bot_5_0 dac_switches_bot_5<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc12_dac_switches_bot_5_1 fe_ofn12_dac_switches_bot_5_1 dac_switches_bot_5<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc11_dac_switches_bot_4_0 fe_ofn11_dac_switches_bot_4_0 dac_switches_bot_4<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc10_dac_switches_bot_4_1 fe_ofn10_dac_switches_bot_4_1 dac_switches_bot_4<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc9_dac_switches_bot_3_0 fe_ofn9_dac_switches_bot_3_0 dac_switches_bot_3<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc8_dac_switches_bot_3_1 fe_ofn8_dac_switches_bot_3_1 dac_switches_bot_3<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc7_dac_switches_bot_2_0 fe_ofn7_dac_switches_bot_2_0 dac_switches_bot_2<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc6_dac_switches_bot_2_1 fe_ofn6_dac_switches_bot_2_1 dac_switches_bot_2<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc5_dac_switches_bot_1_0 fe_ofn5_dac_switches_bot_1_0 dac_switches_bot_1<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc4_dac_switches_bot_1_1 fe_ofn4_dac_switches_bot_1_1 dac_switches_bot_1<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc3_dac_switches_bot_0_0 fe_ofn3_dac_switches_bot_0_0 dac_switches_bot_0<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc2_dac_switches_bot_0_1 fe_ofn2_dac_switches_bot_0_1 dac_switches_bot_0<1> inh_ground inh_power BUFX3MA10TR
xltiehi ltiehi_net inh_ground inh_power TIEHIX1MA10TR
xltielo ltielo_net inh_ground inh_power TIELOX1MA10TR
xfe_phc83_sar_control0_cn_store_next_0 sar_control0_cn_store_next<0> fe_phn83_sar_control0_cn_store_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc82_n6 n6 fe_phn82_n6 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc73_dead_calib_counter_0 dead_calib_counter<0> fe_phn73_dead_calib_counter_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc72_sar_control0_cp_store_0 sar_control0_cp_store<0> fe_phn72_sar_control0_cp_store_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc71_sar_control0_cp_store_1 sar_control0_cp_store<1> fe_phn71_sar_control0_cp_store_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc70_sar_control0_cn_store_0 sar_control0_cn_store<0> fe_phn70_sar_control0_cn_store_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc69_sar_control0_cp_store_2 sar_control0_cp_store<2> fe_phn69_sar_control0_cp_store_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc68_sar_control0_cp_store_3 sar_control0_cp_store<3> fe_phn68_sar_control0_cp_store_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc67_sar_control0_cn_store_2 sar_control0_cn_store<2> fe_phn67_sar_control0_cn_store_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc66_sar_control0_cn_store_3 sar_control0_cn_store<3> fe_phn66_sar_control0_cn_store_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc65_sar_control0_cn_store_1 sar_control0_cn_store<1> fe_phn65_sar_control0_cn_store_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc64_n1 fe_phn87_n1 fe_phn64_n1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc63_n7 n7 fe_phn63_n7 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc62_sar_control0_cp_next_0 sar_control0_cp_next<0> fe_phn62_sar_control0_cp_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc61_sar_control0_cp_store_next_2 sar_control0_cp_store_next<2> fe_phn61_sar_control0_cp_store_next_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc60_sar_control0_cn_next_3 sar_control0_cn_next<3> fe_phn60_sar_control0_cn_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc59_sar_control0_cn_store_next_2 sar_control0_cn_store_next<2> fe_phn59_sar_control0_cn_store_next_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc58_sar_control0_cn_store_next_3 sar_control0_cn_store_next<3> fe_phn58_sar_control0_cn_store_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc57_sar_control0_cn_store_next_1 sar_control0_cn_store_next<1> fe_phn57_sar_control0_cn_store_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc56_sar_control0_cn_next_0 sar_control0_cn_next<0> fe_phn56_sar_control0_cn_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc55_sar_control0_cp_store_next_1 sar_control0_cp_store_next<1> fe_phn55_sar_control0_cp_store_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc54_sar_control0_cn_next_2 sar_control0_cn_next<2> fe_phn54_sar_control0_cn_next_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc53_sar_control0_cn_store_next_0 fe_phn83_sar_control0_cn_store_next_0 fe_phn53_sar_control0_cn_store_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc52_sar_control0_cp_store_next_3 sar_control0_cp_store_next<3> fe_phn52_sar_control0_cp_store_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc51_sar_control0_cp_next_3 sar_control0_cp_next<3> fe_phn51_sar_control0_cp_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc50_sar_control0_cn_next_1 sar_control0_cn_next<1> fe_phn50_sar_control0_cn_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc49_sar_control0_cp_store_next_0 sar_control0_cp_store_next<0> fe_phn49_sar_control0_cp_store_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc48_sar_control0_cp_next_1 sar_control0_cp_next<1> fe_phn48_sar_control0_cp_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc47_sar_control0_cp_next_2 sar_control0_cp_next<2> fe_phn47_sar_control0_cp_next_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc46_n11 n11 fe_phn46_n11 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc45_sar_control0_n71 sar_control0_n71 fe_phn45_sar_control0_n71 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc44_dac_switches_top_7_0 dac_switches_top_7<0> fe_phn44_dac_switches_top_7_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc43_dac_switches_top_4_0 dac_switches_top_4<0> fe_phn43_dac_switches_top_4_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc42_dac_switches_top_3_0 dac_switches_top_3<0> fe_phn42_dac_switches_top_3_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc41_dac_switches_top_6_0 dac_switches_top_6<0> fe_phn41_dac_switches_top_6_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc40_dac_switches_top_5_0 dac_switches_top_5<0> fe_phn40_dac_switches_top_5_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc39_dac_switches_top_1_0 dac_switches_top_1<0> fe_phn39_dac_switches_top_1_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc38_dac_switches_top_2_0 dac_switches_top_2<0> fe_phn38_dac_switches_top_2_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc37_dead_calib_counter_1 dead_calib_counter<1> fe_phn37_dead_calib_counter_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc36_dead_calib_counter_0 fe_phn73_dead_calib_counter_0 fe_phn36_dead_calib_counter_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc35_n54 n54 fe_phn89_n54 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc34_dead_calib_en dead_calib_en fe_phn34_dead_calib_en inh_ground inh_power DLY4X0P5MA10TR
xfe_phc33_n108 n108 fe_phn33_n108 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc32_sar_control0_c_state_0 fe_phn75_sar_control0_c_state_0 fe_phn32_sar_control0_c_state_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc31_sar_control0_c_state_3 fe_phn76_sar_control0_c_state_3 fe_phn31_sar_control0_c_state_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc30_sar_control0_c_state_2 fe_phn74_sar_control0_c_state_2 fe_phn30_sar_control0_c_state_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc29_sar_control0_c_state_1 sar_control0_c_state<1> fe_phn29_sar_control0_c_state_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc28_sar_control0_off_bit sar_control0_off_bit fe_phn28_sar_control0_off_bit inh_ground inh_power DLY4X0P5MA10TR
xfe_phc27_n109 n109 fe_phn27_n109 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc26_n107 n107 fe_phn26_n107 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc89_n54 fe_phn89_n54 fe_phn35_n54 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc84_sar_control0_n148 sar_control0_n148 fe_phn84_sar_control0_n148 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc81_sar_control0_n_state_3 sar_control0_n_state<3> fe_phn81_sar_control0_n_state_3 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc78_dead_calib_en fe_phn34_dead_calib_en fe_phn78_dead_calib_en inh_ground inh_power DLY2X0P5MA10TR
xfe_phc77_sar_control0_c_state_1 fe_phn29_sar_control0_c_state_1 fe_phn77_sar_control0_c_state_1 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc76_sar_control0_c_state_3 sar_control0_c_state<3> fe_phn76_sar_control0_c_state_3 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc75_sar_control0_c_state_0 sar_control0_c_state<0> fe_phn75_sar_control0_c_state_0 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc74_sar_control0_c_state_2 sar_control0_c_state<2> fe_phn74_sar_control0_c_state_2 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc88_sar_control0_n81 sar_control0_n81 fe_phn88_sar_control0_n81 inh_ground inh_power BUFHX1MA10TR
xfe_phc87_n1 n1 fe_phn87_n1 inh_ground inh_power BUFHX1MA10TR
xfe_phc86_n6 fe_phn82_n6 fe_phn86_n6 inh_ground inh_power BUFHX1MA10TR
xfe_phc80_dac_switches_top_3_0 fe_phn42_dac_switches_top_3_0 fe_phn80_dac_switches_top_3_0 inh_ground inh_power BUFHX1MA10TR
xfe_phc79_dac_switches_top_4_0 fe_phn43_dac_switches_top_4_0 fe_phn79_dac_switches_top_4_0 inh_ground inh_power BUFHX1MA10TR
xfe_phc85_n85 n85 fe_phn85_n85 inh_ground inh_power BUFHX0P7MA10TR
.ends adc_cap_dac_8_bit_diff_digital_top_verilog
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc
** View name: schematic
.subckt adc adc_en ain aip calib_en clk eoc_n ext_opt ext_vdd_half firm_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> rst vdd vdd_half vss inh_vdd inh_vss inh_ground inh_power
xi12 ain aip clk net4<0> net4<1> net4<2> net4<3> net7<0> net7<1> net7<2> net7<3> ext_opt ext_vdd_half net88 net3 net2<0> net2<1> net9<0> net9<1> net12<0> net12<1> net14<0> net14<1> net19<0> net19<1> net20<0> net20<1> net21<0> net21<1> net22<0> net22<1> net23<0> net23<1> net24<0> net24<1> net25<0> net25<1> net26<0> net26<1> net28<0> net28<1> net10<0> net10<1> net31<0> net31<1> net35<0> net35<1> net36<0> net36<1> net37<0> net37<1> net1 net5 vdd vdd_half vss adc_cap_dac_8_bit_diff_w_preamp
xi23 clk rst firm_en adc_en calib_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> eoc_n net3 net1 net5 net14<0> net14<1> net12<0> net12<1> net20<0> net20<1> net19<0> net19<1> net22<0> net22<1> net21<0> net21<1> net24<0> net24<1> net23<0> net23<1> net26<0> net26<1> net25<0> net25<1> net10<0> net10<1> net28<0> net28<1> net35<0> net35<1> net31<0> net31<1> net37<0> net37<1> net36<0> net36<1> net9<0> net9<1> net2<0> net2<1> net4<0> net4<1> net4<2> net4<3> net7<0> net7<1> net7<2> net7<3> inh_vdd inh_vss inh_ground inh_power adc_cap_dac_8_bit_diff_digital_top_verilog
.ends adc
** End of subcircuit definition.

** Library name: acadia
** Cell name: CMOS_1_Refs
** View name: schematic
.subckt CMOS_1_Refs vdd vss v_bias v_ref
xm6 net7 net7 vss vss nch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm7 net6 v_ref v_bias vss nch_mac l=2e-6 w=4e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=700e-15 as=700e-15 pd=8.35e-6 ps=8.35e-6 nrd=25e-3 nrs=25e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm9 v_ref v_ref net6 vss nch_mac l=2e-6 w=4e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=700e-15 as=700e-15 pd=8.35e-6 ps=8.35e-6 nrd=25e-3 nrs=25e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm10 v_bias v_ref net32 vss nch_mac l=1e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm4 vbp1 net7 net12 vss nch_mac l=2e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm5 net12 net7 v_bias vss nch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm17 net32 v_ref vss vss nch_mac l=6e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm2 vbp1 vbp1 vdd vdd pch_mac l=20e-6 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=1.98981 scb=1.51359e-3 scc=67.1225e-6 mismatchflag=1
xm3 vss v_ref net12 vdd pch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=10.2513 scb=9.1383e-3 scc=146.598e-6 mismatchflag=1
xm0 net7 vbp1 vdd vdd pch_mac l=10e-6 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=2.22864 scb=1.6089e-3 scc=67.9474e-6 mismatchflag=1
xm11 v_ref vbp1 vdd vdd pch_lvt_mac l=4e-6 w=20e-6 multi=3 nf=1 sigma=1 sd=200e-9 ad=3.5e-12 as=3.5e-12 pd=40.35e-6 ps=40.35e-6 nrd=5e-3 nrs=5e-3 sa=175e-9 sb=175e-9 sca=1.60166 scb=831.124e-6 scc=20.6989e-6 mismatchflag=1
.ends CMOS_1_Refs
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_mixed_tb
** View name: schematic
.subckt adc_mixed_tb adc_en adc_out<7> adc_out<6> adc_out<5> adc_out<4> adc_out<3> adc_out<2> adc_out<1> adc_out<0> calib_en clk eoc_n ext_opt firm_en rst
v13 ain vss! DC=250e-3
v12 aip vss! DC=750e-3
v9 ext_vdd_half vss! DC=500e-3
v6 vss! 0 DC=0
v3 vdd! vss! DC=1
xi21 adc_en ain aip calib_en clk eoc_n ext_opt ext_vdd_half firm_en adc_out<7> adc_out<6> adc_out<5> adc_out<4> adc_out<3> adc_out<2> adc_out<1> adc_out<0> rst vdd! vdd_half vss! vdd! vss! vss! vdd! adc
xi20 vdd! vss! net28 vdd_half CMOS_1_Refs
.ends adc_mixed_tb
** End of subcircuit definition.

.option finesim_output=fsdb
.option finesim_merge_fsdb=1
.option post

.END
