** Generated for: hspiceD
** Generated on: Nov 13 03:17:12 2024
** Design library name: acadia
** Design cell name: analog_top_mixed
** Design view name: schematic
.GLOBAL vdd! vss!

.TEMP 25
.OPTION
+    ARTIST=2
+    INGOLD=2
+    PARHIER=LOCAL
+    PSF=2
+    HIER_DELIM=0
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_bip
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mim
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_dnw
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_bip_npn
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfrtmom
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mos_cap_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_disres
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_res
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_hvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmvar
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_lvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfres_sa
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_esd
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmim
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_mos_cap
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_25ud18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_25ud18
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfjvar
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmos_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rtmom
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na25od33
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_dio_na25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfres_rpo
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_hvt
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfind
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_rfmvar_25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_na25
.LIB "/ece498hk/libs/tsmc65n/PDK/Cadence_OA/tn65cmsp018k3_1_0c/models/hspice/crn65gplus_2d5_lk_v1d0.l" tt_lvt

** Library name: acadia
** Cell name: three_way_switch
** View name: schematic
.subckt three_way_switch a0 s<0> s<2> s<1> vdd vss y
xm4 y sb<1> vdd vdd pch_mac l=60e-9 w=86.4e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=9.504e-12 as=10.2384e-12 pd=90.8e-6 ps=99.78e-6 nrd=1.27315e-3 nrs=1.27315e-3 sa=195e-9 sb=195e-9 sca=3.04936 scb=2.22233e-3 scc=83.1273e-6 mismatchflag=1
xm11 vdd vdd vdd vdd pch_mac l=60e-9 w=4.32e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=842.4e-15 as=842.4e-15 pd=9.03e-6 ps=9.03e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=12.1482 scb=12.1214e-3 scc=203.839e-6 mismatchflag=1
xm0 sb<1> s<1> vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm2 sb<0> s<0> vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm3 y sb<0> a0 vdd pch_mac l=60e-9 w=86.4e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=9.504e-12 as=10.2384e-12 pd=90.8e-6 ps=99.78e-6 nrd=1.27315e-3 nrs=1.27315e-3 sa=195e-9 sb=195e-9 sca=3.04936 scb=2.22233e-3 scc=83.1273e-6 mismatchflag=1
xm7 a0 a0 a0 vdd pch_mac l=60e-9 w=4.32e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=842.4e-15 as=842.4e-15 pd=9.03e-6 ps=9.03e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=12.1482 scb=12.1214e-3 scc=203.839e-6 mismatchflag=1
xm5 y s<2> vss vss nch_mac l=60e-9 w=43.2e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=4.752e-12 as=5.1192e-12 pd=47.6e-6 ps=52.26e-6 nrd=2.5463e-3 nrs=2.5463e-3 sa=195e-9 sb=195e-9 sca=4.86666 scb=3.86386e-3 scc=159.861e-6 mismatchflag=1
xm8 sb<0> s<0> vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm10 a0 a0 a0 vss nch_mac l=60e-9 w=2.16e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm9 y s<0> a0 vss nch_mac l=60e-9 w=43.2e-6 multi=1 nf=20 sigma=1 sd=220e-9 ad=4.752e-12 as=5.1192e-12 pd=47.6e-6 ps=52.26e-6 nrd=2.5463e-3 nrs=2.5463e-3 sa=195e-9 sb=195e-9 sca=4.86666 scb=3.86386e-3 scc=159.861e-6 mismatchflag=1
xm6 sb<1> s<1> vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm12 vss vss vss vss nch_mac l=60e-9 w=2.16e-6 multi=2 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
.ends three_way_switch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_double_tail_comparator_w_offset_calib
** View name: schematic
.subckt adc_double_tail_comparator_w_offset_calib clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb vdd vin vip vss
xm68 net13 cn<3> net1 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm70 vss vss vss vss nch_mac l=780e-9 w=2.7e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=526.5e-15 as=526.5e-15 pd=5.79e-6 ps=5.79e-6 nrd=40.7407e-3 nrs=40.7407e-3 sa=195e-9 sb=195e-9 sca=7.14619 scb=4.70601e-3 scc=137.589e-6 mismatchflag=1
xm67 net15 cn<2> net1 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm69 vss vss vss vss nch_mac l=780e-9 w=2.7e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=526.5e-15 as=526.5e-15 pd=5.79e-6 ps=5.79e-6 nrd=40.7407e-3 nrs=40.7407e-3 sa=195e-9 sb=195e-9 sca=7.14619 scb=4.70601e-3 scc=137.589e-6 mismatchflag=1
xm62 net15 vin net9 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm45 net27 vip net21 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm44 net18 vip net21 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm28 clkb clk vss vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm60 qb net9 vss vss nch_mac l=780e-9 w=54e-6 multi=1 nf=40 sigma=1 sd=220e-9 ad=5.94e-12 as=6.1695e-12 pd=62.8e-6 ps=65.84e-6 nrd=2.03704e-3 nrs=2.03704e-3 sa=195e-9 sb=195e-9 sca=5.92763 scb=5.30485e-3 scc=245.917e-6 mismatchflag=1
xm22 qb q vss vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=17.1389 scb=17.0454e-3 scc=434.039e-6 mismatchflag=1
xm21 q qb vss vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=17.1389 scb=17.0454e-3 scc=434.039e-6 mismatchflag=1
xm3 q net21 vss vss nch_mac l=780e-9 w=54e-6 multi=1 nf=40 sigma=1 sd=220e-9 ad=5.94e-12 as=6.1695e-12 pd=62.8e-6 ps=65.84e-6 nrd=2.03704e-3 nrs=2.03704e-3 sa=195e-9 sb=195e-9 sca=5.92763 scb=5.30485e-3 scc=245.917e-6 mismatchflag=1
xm2 net9 vin net1 vss nch_mac l=60e-9 w=34.56e-6 multi=1 nf=64 sigma=1 sd=220e-9 ad=3.8016e-12 as=3.8934e-12 pd=48.64e-6 ps=50.06e-6 nrd=3.18287e-3 nrs=3.18287e-3 sa=195e-9 sb=195e-9 sca=12.3017 scb=13.1543e-3 scc=615.828e-6 mismatchflag=1
xm1 net21 vip net1 vss nch_mac l=60e-9 w=34.56e-6 multi=1 nf=64 sigma=1 sd=220e-9 ad=3.8016e-12 as=3.8934e-12 pd=48.64e-6 ps=50.06e-6 nrd=3.18287e-3 nrs=3.18287e-3 sa=195e-9 sb=195e-9 sca=12.3017 scb=13.1543e-3 scc=615.828e-6 mismatchflag=1
xm57 net23 vip net21 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm39 net27 cp<1> net1 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm64 net3 vin net9 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm61 net13 vin net9 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm42 net12 vip net21 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm56 net23 cp<0> net1 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm65 net3 cn<0> net1 vss nch_mac l=60e-9 w=1.08e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=118.8e-15 as=164.7e-15 pd=1.96e-6 ps=2.84e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=22.8407 scb=25.9139e-3 scc=1.24861e-3 mismatchflag=1
xm0 net1 clk vss vss nch_mac l=60e-9 w=200e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=31.7909 scb=38.1391e-3 scc=1.7317e-3 mismatchflag=1
xm37 net18 cp<3> net1 vss nch_mac l=60e-9 w=8.64e-6 multi=1 nf=32 sigma=1 sd=220e-9 ad=950.4e-15 as=996.3e-15 pd=15.68e-6 ps=16.56e-6 nrd=12.7315e-3 nrs=12.7315e-3 sa=195e-9 sb=195e-9 sca=19.2209 scb=23.373e-3 scc=1.22064e-3 mismatchflag=1
xm72 net1 net1 net1 vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm63 net11 vin net9 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm38 net12 cp<2> net1 vss nch_mac l=60e-9 w=4.32e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=475.2e-15 as=521.1e-15 pd=7.84e-6 ps=8.72e-6 nrd=25.463e-3 nrs=25.463e-3 sa=195e-9 sb=195e-9 sca=19.8439 scb=23.736e-3 scc=1.22464e-3 mismatchflag=1
xm66 net11 cn<1> net1 vss nch_mac l=60e-9 w=2.16e-6 multi=1 nf=8 sigma=1 sd=220e-9 ad=237.6e-15 as=283.5e-15 pd=3.92e-6 ps=4.8e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=20.9709 scb=24.462e-3 scc=1.23263e-3 mismatchflag=1
xm71 net1 net1 net1 vss nch_mac l=60e-9 w=540e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=105.3e-15 as=105.3e-15 pd=1.47e-6 ps=1.47e-6 nrd=203.704e-3 nrs=203.704e-3 sa=195e-9 sb=195e-9 sca=22.1076 scb=23.4527e-3 scc=740.935e-6 mismatchflag=1
xm27 clkb clk vdd vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm26 net74 clkb vdd vdd pch_mac l=60e-9 w=200e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=39e-15 as=39e-15 pd=790e-9 ps=790e-9 nrd=550e-3 nrs=550e-3 sa=195e-9 sb=195e-9 sca=31.7909 scb=38.1391e-3 scc=1.7317e-3 mismatchflag=1
xm25 qb q net74 vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm24 q qb net74 vdd pch_mac l=60e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=13.9656 scb=13.7629e-3 scc=280.572e-6 mismatchflag=1
xm20 net21 clk vdd vdd pch_mac l=60e-9 w=270e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=28.6987 scb=33.4899e-3 scc=1.34375e-3 mismatchflag=1
xm19 net9 clk vdd vdd pch_mac l=60e-9 w=270e-9 multi=1 nf=1 sigma=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=28.6987 scb=33.4899e-3 scc=1.34375e-3 mismatchflag=1
.ends adc_double_tail_comparator_w_offset_calib
** End of subcircuit definition.

** Library name: acadia
** Cell name: nor2
** View name: schematic
.subckt nor2 a b vdd vss y
m3 y b net1 vdd pch l=180e-9 w=1.08e-6 m=1 nf=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6
m1 net1 a vdd vdd pch l=180e-9 w=1.08e-6 m=1 nf=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6
m2 y b vss vss nch l=180e-9 w=270e-9 m=1 nf=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=26.6525 scb=30.0185e-3 scc=1.27841e-3
m0 y a vss vss nch l=180e-9 w=270e-9 m=1 nf=1 sd=220e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=195e-9 sb=195e-9 sca=26.6525 scb=30.0185e-3 scc=1.27841e-3
.ends nor2
** End of subcircuit definition.

** Library name: acadia
** Cell name: srlatch
** View name: schematic
.subckt srlatch q qb r s vdd vss
xi2 q s vdd vss qb nor2
xi0 r qb vdd vss q nor2
.ends srlatch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_double_tail_comparator_w_offset_calib_w_srlatch
** View name: schematic
.subckt adc_double_tail_comparator_w_offset_calib_w_srlatch clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb vdd vin vip vss
xi8 net7 cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> strong_q strong_qb vdd vin vip vss adc_double_tail_comparator_w_offset_calib
xi9 q qb strong_q strong_qb vdd vss srlatch
xm2 net7 clk vss vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm3 net7 clk vdd vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
.ends adc_double_tail_comparator_w_offset_calib_w_srlatch
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_cap_dac_8_bit_diff_w_preamp
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_w_preamp ain aip clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> ext_opt ext_vdd_half q qb s0<1> s0<0> s0_top<1> s0_top<0> s1<1> s1<0> s1_top<1> s1_top<0> s2<1> s2<0> s2_top<1> s2_top<0> s3<1> s3<0> s3_top<1> s3_top<0> s4<1> s4<0> s4_top<1> s4_top<0> s5<1> s5<0> s5_top<1> s5_top<0> s6<1> s6<0> s6_top<1> s6_top<0> s7<1> s7<0> s7_top<1> s7_top<0> s8<1> s8<0> s8_top<1> s8_top<0> sc sc1 inh_vdd vdd_half inh_vss real_vdd_half vin vip
xi59 aip sc s7_top<1> s7_top<0> inh_vdd inh_vss c7_top three_way_switch
xi58 aip sc s4_top<1> s4_top<0> inh_vdd inh_vss c4_top three_way_switch
xi57 aip sc s5_top<1> s5_top<0> inh_vdd inh_vss c5_top three_way_switch
xi56 aip sc s6_top<1> s6_top<0> inh_vdd inh_vss c6_top three_way_switch
xi55 aip sc s3_top<1> s3_top<0> inh_vdd inh_vss c3_top three_way_switch
xi54 aip sc s1_top<1> s1_top<0> inh_vdd inh_vss c1_top three_way_switch
xi53 aip sc s0_top<1> s0_top<0> inh_vdd inh_vss c0_top three_way_switch
xi52 aip sc s2_top<1> s2_top<0> inh_vdd inh_vss c2_top three_way_switch
xi60 ain sc1 s7<1> s7<0> inh_vdd inh_vss c7_bot three_way_switch
xi50 ain sc1 s8<1> s8<0> inh_vdd inh_vss c8_bot three_way_switch
xi49 ain sc1 s2<1> s2<0> inh_vdd inh_vss c2_bot three_way_switch
xi48 ain sc1 s0<1> s0<0> inh_vdd inh_vss c0_bot three_way_switch
xi47 ain sc1 s1<1> s1<0> inh_vdd inh_vss c1_bot three_way_switch
xi46 ain sc1 s3<1> s3<0> inh_vdd inh_vss c3_bot three_way_switch
xi45 ain sc1 s6<1> s6<0> inh_vdd inh_vss c6_bot three_way_switch
xi44 ain sc1 s5<1> s5<0> inh_vdd inh_vss c5_bot three_way_switch
xi43 ain sc1 s4<1> s4<0> inh_vdd inh_vss c4_bot three_way_switch
xi61 aip sc s8_top<1> s8_top<0> inh_vdd inh_vss c8_top three_way_switch
xc45 vin c8_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=128 mismatchflag=1
xc44 vin c1_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc28 vin c0_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc30 vin c3_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=4 mismatchflag=1
xc31 vin c4_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=8 mismatchflag=1
xc32 vin c5_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=16 mismatchflag=1
xc33 vin c6_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=32 mismatchflag=1
xc34 vin c7_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=64 mismatchflag=1
xc35 vip c2_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=2 mismatchflag=1
xc36 vip c7_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=64 mismatchflag=1
xc37 vip c6_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=32 mismatchflag=1
xc38 vip c5_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=16 mismatchflag=1
xc39 vip c4_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=8 mismatchflag=1
xc1 inh_vss inh_vss inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=84 mismatchflag=1
xc0 inh_vss inh_vss inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=84 mismatchflag=1
xc41 vip c0_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc42 vip c1_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=1 mismatchflag=1
xc40 vip c3_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=4 mismatchflag=1
xc43 vip c8_top inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=128 mismatchflag=1
xc29 vin c2_bot inh_vss crtmom nv=28 nh=28 w=130e-9 s=130e-9 stm=1 spm=5 mf=2 mismatchflag=1
xi41 clk cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> q qb inh_vdd vin vip inh_vss adc_double_tail_comparator_w_offset_calib_w_srlatch
xm5 scb sc inh_vss inh_vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm3 vip sc real_vdd_half inh_vss nch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm17 real_vdd_half real_vdd_half real_vdd_half inh_vss nch_mac l=180e-9 w=400e-9 multi=4 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm15 ext_vdd_half ext_vdd_half ext_vdd_half inh_vss nch_mac l=180e-9 w=400e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm0 vin sc real_vdd_half inh_vss nch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm12 vdd_half vdd_half vdd_half inh_vss nch_mac l=180e-9 w=400e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm6 ext_optb ext_opt inh_vss inh_vss nch_mac l=180e-9 w=1.08e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=195e-9 sb=195e-9 sca=15.0926 scb=13.574e-3 scc=368.7e-6 mismatchflag=1
xm11 real_vdd_half ext_opt ext_vdd_half inh_vss nch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm8 real_vdd_half ext_optb vdd_half inh_vss nch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm13 vdd_half vdd_half vdd_half inh_vdd pch_mac l=180e-9 w=400e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm1 vin scb real_vdd_half inh_vdd pch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm4 scb sc inh_vdd inh_vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm2 vip scb real_vdd_half inh_vdd pch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm16 real_vdd_half real_vdd_half real_vdd_half inh_vdd pch_mac l=180e-9 w=400e-9 multi=4 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm14 ext_vdd_half ext_vdd_half ext_vdd_half inh_vdd pch_mac l=180e-9 w=400e-9 multi=2 nf=1 sigma=1 sd=220e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=195e-9 sb=195e-9 sca=22.7624 scb=24.0064e-3 scc=889.798e-6 mismatchflag=1
xm7 ext_optb ext_opt inh_vdd inh_vdd pch_mac l=180e-9 w=2.16e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=421.2e-15 as=421.2e-15 pd=4.71e-6 ps=4.71e-6 nrd=50.9259e-3 nrs=50.9259e-3 sa=195e-9 sb=195e-9 sca=11.9193 scb=10.2915e-3 scc=215.234e-6 mismatchflag=1
xm10 real_vdd_half ext_optb ext_vdd_half inh_vdd pch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
xm9 real_vdd_half ext_opt vdd_half inh_vdd pch_mac l=180e-9 w=6.4e-6 multi=1 nf=16 sigma=1 sd=220e-9 ad=704e-15 as=772e-15 pd=9.92e-6 ps=11.06e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=15.557 scb=17.4511e-3 scc=831.893e-6 mismatchflag=1
.ends adc_cap_dac_8_bit_diff_w_preamp
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP16A10TR
** View name: schematic
.subckt FILLCAP16A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=5.17e-6 m=1 nf=1 sd=200e-9 ad=1.00815e-12 as=1.00815e-12 pd=10.73e-6 ps=10.73e-6 nrd=21.2766e-3 nrs=21.2766e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=7.7e-6 m=1 nf=1 sd=200e-9 ad=1.5015e-12 as=1.5015e-12 pd=15.79e-6 ps=15.79e-6 nrd=14.2857e-3 nrs=14.2857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP16A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP32A10TR
** View name: schematic
.subckt FILLCAP32A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=10.81e-6 m=1 nf=1 sd=200e-9 ad=2.10795e-12 as=2.10795e-12 pd=22.01e-6 ps=22.01e-6 nrd=10.1758e-3 nrs=10.1758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=16.1e-6 m=1 nf=1 sd=200e-9 ad=3.1395e-12 as=3.1395e-12 pd=32.59e-6 ps=32.59e-6 nrd=6.8323e-3 nrs=6.8323e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP32A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP8A10TR
** View name: schematic
.subckt FILLCAP8A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=2.35e-6 m=1 nf=1 sd=200e-9 ad=458.25e-15 as=458.25e-15 pd=5.09e-6 ps=5.09e-6 nrd=46.8085e-3 nrs=46.8085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=3.5e-6 m=1 nf=1 sd=200e-9 ad=682.5e-15 as=682.5e-15 pd=7.39e-6 ps=7.39e-6 nrd=31.4286e-3 nrs=31.4286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP8A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP4A10TR
** View name: schematic
.subckt FILLCAP4A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=940e-9 m=1 nf=1 sd=200e-9 ad=183.3e-15 as=183.3e-15 pd=2.27e-6 ps=2.27e-6 nrd=117.021e-3 nrs=117.021e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP4A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP64A10TR
** View name: schematic
.subckt FILLCAP64A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=22.56e-6 m=1 nf=1 sd=200e-9 ad=4.3992e-12 as=4.3992e-12 pd=45.51e-6 ps=45.51e-6 nrd=4.87589e-3 nrs=4.87589e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=130e-9 w=33.6e-6 m=1 nf=1 sd=200e-9 ad=6.552e-12 as=6.552e-12 pd=67.59e-6 ps=67.59e-6 nrd=3.27381e-3 nrs=3.27381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP64A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: FILLCAP3A10TR
** View name: schematic
.subckt FILLCAP3A10TR inh_ground inh_power
mn1 net10 net9 inh_ground inh_ground nch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 net9 net10 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends FILLCAP3A10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AO22X0P5MA10TR
** View name: schematic
.subckt AO22X0P5MA10TR a0 a1 b0 b1 y inh_ground inh_power
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 int a0 n1b inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 int b0 n1a inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b1 p1 inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa109 int b0 p1 inh_power pch l=60e-9 w=385e-9 m=1 nf=1 sd=200e-9 ad=75.075e-15 as=75.075e-15 pd=1.16e-6 ps=1.16e-6 nrd=285.714e-3 nrs=285.714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AO22X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI21X0P5MA10TR
** View name: schematic
.subckt AOI21X0P5MA10TR a0 a1 b0 y inh_ground inh_power
mnb1 y a0 n1 inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI21X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI21X0P5MA10TR
** View name: schematic
.subckt OAI21X0P5MA10TR a0 a1 b0 y inh_ground inh_power
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 inh_power inh_power pch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI21X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND2X0P5BA10TR
** View name: schematic
.subckt NAND2X0P5BA10TR a b y inh_ground inh_power
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND2X0P5BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX0P5BA10TR
** View name: schematic
.subckt INVX0P5BA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX0P5BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2X0P5AA10TR
** View name: schematic
.subckt NOR2X0P5AA10TR a b y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=245e-9 m=1 nf=1 sd=200e-9 ad=47.775e-15 as=47.775e-15 pd=880e-9 ps=880e-9 nrd=448.98e-3 nrs=448.98e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=245e-9 m=1 nf=1 sd=200e-9 ad=47.775e-15 as=47.775e-15 pd=880e-9 ps=880e-9 nrd=448.98e-3 nrs=448.98e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2X0P5AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQNX0P5MA10TR
** View name: schematic
.subckt DFFRPQNX0P5MA10TR ck d qn r inh_ground inh_power
mna2 m r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe026 nm nclk nin inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1038 m nm inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe030 s bclk m inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 net40 s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1010 nin d inh_ground inh_ground nch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net50 net40 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net50 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1034 qn s inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen028 nm bclk nin inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 bclk nclk inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 net40 s inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen032 s nclk m inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1012 nin d inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_12 r inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1041 m nm p1_12 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm nclk p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1022 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1036 qn s inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net36 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net39 net40 net36 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net39 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQNX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX0P5MA10TR
** View name: schematic
.subckt DFFRPQX0P5MA10TR ck d q r inh_ground inh_power
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1018 m nm inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe036 nm nclk nin inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nin d inh_ground inh_ground nch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net63 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net63 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1028 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen038 nm bclk nin inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nin d inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 r inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1021 m nm p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1030 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net77 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net83 ns net77 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net83 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: PREICGX2BA10TR
** View name: schematic
.subckt PREICGX2BA10TR ck e eck se inh_ground inh_power
mn0 nout ck n1 inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe05 nm ck n1_6 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 eck nout inh_ground inh_ground nch l=60e-9 w=720e-9 m=1 nf=1 sd=200e-9 ad=140.4e-15 as=140.4e-15 pd=1.83e-6 ps=1.83e-6 nrd=152.778e-3 nrs=152.778e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1_6 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nclk_ ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 m nm inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm nclk_ nen inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 m inh_ground inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 nen se inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 nen e inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nclk_ ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 eck nout inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm ck nen inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 m nm inh_power inh_power pch l=60e-9 w=215e-9 m=1 nf=1 sd=200e-9 ad=41.925e-15 as=41.925e-15 pd=820e-9 ps=820e-9 nrd=511.628e-3 nrs=511.628e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 nout ck inh_power inh_power pch l=60e-9 w=410e-9 m=1 nf=1 sd=200e-9 ad=79.95e-15 as=79.95e-15 pd=1.21e-6 ps=1.21e-6 nrd=268.293e-3 nrs=268.293e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 nout m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen07 nm nclk_ p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1023 nen e p1_9 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_9 se inh_power inh_power pch l=60e-9 w=560e-9 m=1 nf=1 sd=200e-9 ad=109.2e-15 as=109.2e-15 pd=1.51e-6 ps=1.51e-6 nrd=196.429e-3 nrs=196.429e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends PREICGX2BA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX2MA10TR
** View name: schematic
.subckt DFFRPQX2MA10TR ck d q r inh_ground inh_power
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1013 m r inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm nclk net32 inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=210e-9 m=1 nf=1 sd=200e-9 ad=40.95e-15 as=40.95e-15 pd=810e-9 ps=810e-9 nrd=523.81e-3 nrs=523.81e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net32 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=1.06e-6 m=1 nf=1 sd=200e-9 ad=206.7e-15 as=206.7e-15 pd=2.51e-6 ps=2.51e-6 nrd=103.774e-3 nrs=103.774e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net106 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net106 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1024 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=360e-9 m=1 nf=1 sd=200e-9 ad=70.2e-15 as=70.2e-15 pd=1.11e-6 ps=1.11e-6 nrd=305.556e-3 nrs=305.556e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=600e-9 m=1 nf=1 sd=200e-9 ad=117e-15 as=117e-15 pd=1.59e-6 ps=1.59e-6 nrd=183.333e-3 nrs=183.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm bclk net32 inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=260e-9 m=1 nf=1 sd=200e-9 ad=50.7e-15 as=50.7e-15 pd=910e-9 ps=910e-9 nrd=423.077e-3 nrs=423.077e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net32 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1026 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1016 m r p1 inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net96 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net102 ns net96 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net102 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX2MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: PREICGX3BA10TR
** View name: schematic
.subckt PREICGX3BA10TR ck e eck se inh_ground inh_power
mna1026 eck nout inh_ground inh_ground nch l=60e-9 w=1.08e-6 m=1 nf=1 sd=200e-9 ad=210.6e-15 as=210.6e-15 pd=2.55e-6 ps=2.55e-6 nrd=101.852e-3 nrs=101.852e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 m nm inh_ground inh_ground nch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nclk_ ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm nclk_ nen inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 m inh_ground inh_ground nch l=60e-9 w=520e-9 m=1 nf=1 sd=200e-9 ad=101.4e-15 as=101.4e-15 pd=1.43e-6 ps=1.43e-6 nrd=211.538e-3 nrs=211.538e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 nout ck n1 inh_ground nch l=60e-9 w=520e-9 m=1 nf=1 sd=200e-9 ad=101.4e-15 as=101.4e-15 pd=1.43e-6 ps=1.43e-6 nrd=211.538e-3 nrs=211.538e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1_6 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe05 nm ck n1_6 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 nen se inh_ground inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 nen e inh_ground inh_ground nch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nclk_ ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 m nm inh_power inh_power pch l=60e-9 w=270e-9 m=1 nf=1 sd=200e-9 ad=52.65e-15 as=52.65e-15 pd=930e-9 ps=930e-9 nrd=407.407e-3 nrs=407.407e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 eck nout inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm ck nen inh_power pch l=60e-9 w=160e-9 m=1 nf=1 sd=390e-9 ad=31.2e-15 as=31.2e-15 pd=710e-9 ps=710e-9 nrd=687.5e-3 nrs=687.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 nout ck inh_power inh_power pch l=60e-9 w=630e-9 m=1 nf=1 sd=200e-9 ad=122.85e-15 as=122.85e-15 pd=1.65e-6 ps=1.65e-6 nrd=174.603e-3 nrs=174.603e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 nout m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen07 nm nclk_ p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1023 nen e p1_9 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_9 se inh_power inh_power pch l=60e-9 w=560e-9 m=1 nf=1 sd=200e-9 ad=109.2e-15 as=109.2e-15 pd=1.51e-6 ps=1.51e-6 nrd=196.429e-3 nrs=196.429e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends PREICGX3BA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX3BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DLY4X0P5MA10TR
** View name: schematic
.subckt DLY4X0P5MA10TR a y inh_ground inh_power
mnoe014 nin a n1_5 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1010 n1_5 a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 inh_ground nbin inh_ground inh_ground nch l=60e-9 w=185e-9 m=1 nf=1 sd=200e-9 ad=36.075e-15 as=36.075e-15 pd=760e-9 ps=760e-9 nrd=594.595e-3 nrs=594.595e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1018 n1_9 nin inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe022 bin nin n1_9 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1 bin inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nbin bin n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 y nbin inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1012 p1_7 a inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 inh_power nbin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen016 nin a p1_7 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 y nbin inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nbin bin p1 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 bin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1020 p1_11 nin inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen024 bin nin p1_11 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DLY4X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DLY2X0P5MA10TR
** View name: schematic
.subckt DLY2X0P5MA10TR a y inh_ground inh_power
mn0 inh_ground net15 inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 n1 a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe net15 a n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net15 inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 inh_power net15 inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net15 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 p1 a inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen net15 a p1 inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DLY2X0P5MA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: adc_cap_dac_8_bit_diff_adc_regs
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_adc_regs clk rst d<7> d<6> d<5> d<4> d<3> d<2> d<1> d<0> load q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> ltielo_net inh_ground inh_power
xq_reg_1_ net293 fe_phn69_dac_switches_top_1_0 q<1> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_7_ net293 fe_phn35_dac_switches_top_7_0 q<7> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_2_ net293 fe_phn41_dac_switches_top_2_0 q<2> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_3_ net293 d<3> q<3> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_4_ net293 fe_phn36_dac_switches_top_4_0 q<4> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_5_ net293 fe_phn34_dac_switches_top_5_0 q<5> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_6_ net293 fe_phn38_dac_switches_top_6_0 q<6> rst inh_ground inh_power DFFRPQX2MA10TR
xq_reg_0_ net293 d<0> q<0> rst inh_ground inh_power DFFRPQX2MA10TR
xclk_gate_q_reg clk load net293 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_adc_regs
xfe_phc43_dac_switches_top_1_0 d<1> fe_phn43_dac_switches_top_1_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc41_dac_switches_top_2_0 d<2> fe_phn41_dac_switches_top_2_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc38_dac_switches_top_6_0 d<6> fe_phn38_dac_switches_top_6_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc36_dac_switches_top_4_0 d<4> fe_phn36_dac_switches_top_4_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc35_dac_switches_top_7_0 d<7> fe_phn35_dac_switches_top_7_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc34_dac_switches_top_5_0 d<5> fe_phn34_dac_switches_top_5_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc69_dac_switches_top_1_0 fe_phn43_dac_switches_top_1_0 fe_phn69_dac_switches_top_1_0 inh_ground inh_power DLY2X0P5MA10TR
.ends adc_cap_dac_8_bit_diff_adc_regs
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND4XXXBX0P5MA10TR
** View name: schematic
.subckt NAND4XXXBX0P5MA10TR a b c dn y inh_ground inh_power
mna3 n2 c n1 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y a n3 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n3 b n2 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 net32 dn inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna4 n1 net32 inh_ground inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net32 dn inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa105 y a inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa4 y net32 inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND4XXXBX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND4X0P5MA10TR
** View name: schematic
.subckt NAND4X0P5MA10TR a b c d y inh_ground inh_power
mna4 n1 d inh_ground inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 n2 c n1 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n3 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n3 b n2 inh_ground nch l=60e-9 w=310e-9 m=1 nf=1 sd=200e-9 ad=60.45e-15 as=60.45e-15 pd=1.01e-6 ps=1.01e-6 nrd=354.839e-3 nrs=354.839e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa4 y d inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND4X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI22X0P5MA10TR
** View name: schematic
.subckt OAI22X0P5MA10TR a0 a1 b0 b1 y inh_ground inh_power
mna1 y b0 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b1 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1a b1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1b a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1a inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1b inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI22X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: ADDFX1MA10TR
** View name: schematic
.subckt ADDFX1MA10TR a b ci co s inh_ground inh_power
mn7 nsum ncout n2 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 ncout ci n1 inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 n2 a inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn8 n2 b inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 n1 b inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn6 n2 ci inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 n1 a inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 net34 b inh_ground inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 ncout a net34 inh_ground nch l=60e-9 w=390e-9 m=1 nf=1 sd=200e-9 ad=76.05e-15 as=76.05e-15 pd=1.17e-6 ps=1.17e-6 nrd=282.051e-3 nrs=282.051e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 co ncout inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1022 s nsum inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn11 net46 b inh_ground inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn10 net49 a net46 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn9 nsum ci net49 inh_ground nch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 ncout ci p1 inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 p1 a inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p1 b inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp7 nsum ncout p2 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p2 a inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp6 p2 ci inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp8 p2 b inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 ncout a net69 inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 net69 b inh_power inh_power pch l=60e-9 w=650e-9 m=1 nf=1 sd=200e-9 ad=126.75e-15 as=126.75e-15 pd=1.69e-6 ps=1.69e-6 nrd=169.231e-3 nrs=169.231e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 co ncout inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1024 s nsum inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp11 net84 b inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp10 net87 a net84 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp9 nsum ci net87 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends ADDFX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI221X0P5MA10TR
** View name: schematic
.subckt AOI221X0P5MA10TR a0 a1 b0 b1 c0 y inh_ground inh_power
mn4 y a0 net17 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net26 b1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 y b0 net26 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 p2 b1 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 p2 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p2 b0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI221X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI2XB1X0P5MA10TR
** View name: schematic
.subckt OAI2XB1X0P5MA10TR a0 a1n b0 y inh_ground inh_power
mna1 int a1n inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 y b0 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 int inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 int inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 y b0 inh_power inh_power pch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 int a1n inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI2XB1X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI21BX0P5MA10TR
** View name: schematic
.subckt AOI21BX0P5MA10TR a0 a1 b0n y inh_ground inh_power
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 net28 b0n inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 y a0 n1 inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 y net28 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net28 b0n inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 y net28 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI21BX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AND2X0P5MA10TR
** View name: schematic
.subckt AND2X0P5MA10TR a b y inh_ground inh_power
mna1 int a n1 inh_ground nch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 y int inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 int a inh_power inh_power pch l=60e-9 w=155e-9 m=1 nf=1 sd=390e-9 ad=30.225e-15 as=30.225e-15 pd=700e-9 ps=700e-9 nrd=709.677e-3 nrs=709.677e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 y int inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 int b inh_power inh_power pch l=60e-9 w=155e-9 m=1 nf=1 sd=390e-9 ad=30.225e-15 as=30.225e-15 pd=700e-9 ps=700e-9 nrd=709.677e-3 nrs=709.677e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AND2X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2BX0P5MA10TR
** View name: schematic
.subckt NOR2BX0P5MA10TR an b y inh_ground inh_power
mna2 y b inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 net24 an inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net24 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 net24 an inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net24 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2BX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI211X0P5MA10TR
** View name: schematic
.subckt AOI211X0P5MA10TR a0 a1 b0 c0 y inh_ground inh_power
mn3 y b0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 y a0 net17 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net045 b0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 net045 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI211X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI211X0P5MA10TR
** View name: schematic
.subckt OAI211X0P5MA10TR a0 a1 b0 c0 y inh_ground inh_power
mnc2 n1 a1 inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnc1 n1 a0 inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n2 b0 n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y c0 n2 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc2 p1 a1 inh_power inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y c0 inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpc1 y a0 p1 inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y b0 inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI211X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI22X0P5MA10TR
** View name: schematic
.subckt AOI22X0P5MA10TR a0 a1 b0 b1 y inh_ground inh_power
mnb2 n1b a1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 y a0 n1b inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1a inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b1 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI22X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: XNOR2X0P5MA10TR
** View name: schematic
.subckt XNOR2X0P5MA10TR a b y inh_ground inh_power
mna1 nin2 b inh_ground inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe y nin1 nin2 inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 nin1 a inh_ground inh_ground nch l=60e-9 w=275e-9 m=1 nf=1 sd=200e-9 ad=53.625e-15 as=53.625e-15 pd=940e-9 ps=940e-9 nrd=400e-3 nrs=400e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe02 y a bin2 inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 bin2 nin2 inh_ground inh_ground nch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen y a nin2 inh_power pch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nin2 b inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen04 y nin1 bin2 inh_power pch l=60e-9 w=235e-9 m=1 nf=1 sd=200e-9 ad=45.825e-15 as=45.825e-15 pd=860e-9 ps=860e-9 nrd=468.085e-3 nrs=468.085e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 bin2 nin2 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 nin1 a inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends XNOR2X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI31X0P5MA10TR
** View name: schematic
.subckt AOI31X0P5MA10TR a0 a1 a2 b0 y inh_ground inh_power
mnb1 y a0 n2 inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb3 n1 a2 inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n2 a1 n1 inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb3 p1 a2 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=370e-9 m=1 nf=1 sd=200e-9 ad=72.15e-15 as=72.15e-15 pd=1.13e-6 ps=1.13e-6 nrd=297.297e-3 nrs=297.297e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI31X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI32X0P5MA10TR
** View name: schematic
.subckt AOI32X0P5MA10TR a0 a1 a2 b0 b1 y inh_ground inh_power
mna1 y b0 n1a inh_ground nch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n2b a1 n1b inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1a b1 inh_ground inh_ground nch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb3 n1b a2 inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 y a0 n2b inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 p1 inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb3 p1 a2 inh_power inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b1 p1 inh_power pch l=60e-9 w=335e-9 m=1 nf=1 sd=200e-9 ad=65.325e-15 as=65.325e-15 pd=1.06e-6 ps=1.06e-6 nrd=328.358e-3 nrs=328.358e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI32X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2X0P7MA10TR
** View name: schematic
.subckt NOR2X0P7MA10TR a b y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p1 inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2X0P7MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI222X0P5MA10TR
** View name: schematic
.subckt AOI222X0P5MA10TR a0 a1 b0 b1 c0 c1 y inh_ground inh_power
mn3 y b0 net26 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 y a0 net17 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net26 b1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 net29 c1 inh_ground inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 net29 inh_ground nch l=60e-9 w=165e-9 m=1 nf=1 sd=390e-9 ad=32.175e-15 as=32.175e-15 pd=720e-9 ps=720e-9 nrd=666.667e-3 nrs=666.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 p2 b1 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 p2 b0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 y c1 p2 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 p2 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI222X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND2BX0P5MA10TR
** View name: schematic
.subckt NAND2BX0P5MA10TR an b y inh_ground inh_power
mna104 net24 an inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y net24 n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 net24 an inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y net24 inh_power inh_power pch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND2BX0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND3BX0P7MA10TR
** View name: schematic
.subckt NAND3BX0P7MA10TR an b c y inh_ground inh_power
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=410e-9 m=1 nf=1 sd=200e-9 ad=79.95e-15 as=79.95e-15 pd=1.21e-6 ps=1.21e-6 nrd=268.293e-3 nrs=268.293e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 net14 an inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net14 n2 inh_ground nch l=60e-9 w=410e-9 m=1 nf=1 sd=200e-9 ad=79.95e-15 as=79.95e-15 pd=1.21e-6 ps=1.21e-6 nrd=268.293e-3 nrs=268.293e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=410e-9 m=1 nf=1 sd=200e-9 ad=79.95e-15 as=79.95e-15 pd=1.21e-6 ps=1.21e-6 nrd=268.293e-3 nrs=268.293e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net14 an inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa105 y net14 inh_power inh_power pch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND3BX0P7MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX0P7BA10TR
** View name: schematic
.subckt INVX0P7BA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=255e-9 m=1 nf=1 sd=200e-9 ad=49.725e-15 as=49.725e-15 pd=900e-9 ps=900e-9 nrd=431.372e-3 nrs=431.372e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX0P7BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND3X0P5MA10TR
** View name: schematic
.subckt NAND3X0P5MA10TR a b c y inh_ground inh_power
mna3 n1 c inh_ground inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n2 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 n2 b n1 inh_ground nch l=60e-9 w=290e-9 m=1 nf=1 sd=200e-9 ad=56.55e-15 as=56.55e-15 pd=970e-9 ps=970e-9 nrd=379.31e-3 nrs=379.31e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 y c inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND3X0P5MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR3X0P7MA10TR
** View name: schematic
.subckt NOR3X0P7MA10TR a b c y inh_ground inh_power
mna3 y c inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 inh_power c n_5 inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 n_3 a y inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 n_5 b n_3 inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR3X0P7MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NAND2X0P7BA10TR
** View name: schematic
.subckt NAND2X0P7BA10TR a b y inh_ground inh_power
mna2 n1 b inh_ground inh_ground nch l=60e-9 w=405e-9 m=1 nf=1 sd=200e-9 ad=78.975e-15 as=78.975e-15 pd=1.2e-6 ps=1.2e-6 nrd=271.605e-3 nrs=271.605e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y a n1 inh_ground nch l=60e-9 w=405e-9 m=1 nf=1 sd=200e-9 ad=78.975e-15 as=78.975e-15 pd=1.2e-6 ps=1.2e-6 nrd=271.605e-3 nrs=271.605e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 y b inh_power inh_power pch l=60e-9 w=490e-9 m=1 nf=1 sd=200e-9 ad=95.55e-15 as=95.55e-15 pd=1.37e-6 ps=1.37e-6 nrd=224.49e-3 nrs=224.49e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NAND2X0P7BA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AOI211X1MA10TR
** View name: schematic
.subckt AOI211X1MA10TR a0 a1 b0 c0 y inh_ground inh_power
mn3 y b0 inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn5 net17 a1 inh_ground inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 y a0 net17 inh_ground nch l=60e-9 w=330e-9 m=1 nf=1 sd=200e-9 ad=64.35e-15 as=64.35e-15 pd=1.05e-6 ps=1.05e-6 nrd=333.333e-3 nrs=333.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 y c0 inh_ground inh_ground nch l=60e-9 w=205e-9 m=1 nf=1 sd=200e-9 ad=39.975e-15 as=39.975e-15 pd=800e-9 ps=800e-9 nrd=536.585e-3 nrs=536.585e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 y c0 net045 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp4 p1 a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net045 b0 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 p1 a0 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AOI211X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR3X0P5AA10TR
** View name: schematic
.subckt NOR3X0P5AA10TR a b c y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna3 y c inh_ground inh_ground nch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa3 p1 c inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p2 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p2 b p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR3X0P5AA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: NOR2X1MA10TR
** View name: schematic
.subckt NOR2X1MA10TR a b y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=285e-9 m=1 nf=1 sd=200e-9 ad=55.575e-15 as=55.575e-15 pd=960e-9 ps=960e-9 nrd=385.965e-3 nrs=385.965e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 y b inh_ground inh_ground nch l=60e-9 w=285e-9 m=1 nf=1 sd=200e-9 ad=55.575e-15 as=55.575e-15 pd=960e-9 ps=960e-9 nrd=385.965e-3 nrs=385.965e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 b inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends NOR2X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI21X1MA10TR
** View name: schematic
.subckt OAI21X1MA10TR a0 a1 b0 y inh_ground inh_power
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y b0 n1 inh_ground nch l=60e-9 w=455e-9 m=1 nf=1 sd=200e-9 ad=88.725e-15 as=88.725e-15 pd=1.3e-6 ps=1.3e-6 nrd=241.758e-3 nrs=241.758e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y b0 inh_power inh_power pch l=60e-9 w=380e-9 m=1 nf=1 sd=200e-9 ad=74.1e-15 as=74.1e-15 pd=1.15e-6 ps=1.15e-6 nrd=289.474e-3 nrs=289.474e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI21X1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQNX1MA10TR
** View name: schematic
.subckt DFFRPQNX1MA10TR ck d qn r inh_ground inh_power
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 net37 s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1034 m r inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe014 nm nclk nin inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe018 s bclk m inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 nin d inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net53 net37 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net53 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1022 nclk ck inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1030 qn s inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm nclk p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net37 s inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen016 nm bclk nin inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 bclk nclk inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen020 s nclk m inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 nin d inh_power inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1037 m r p1_12 inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_12 nm inh_power inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1024 nclk ck inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1032 qn s inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net36 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net39 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net36 net37 net39 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQNX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX1MA10TR
** View name: schematic
.subckt DFFRPQX1MA10TR ck d q r inh_ground inh_power
mna1014 m r inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna104 bclk nclk inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe032 nm nclk net055 inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=170e-9 m=1 nf=1 sd=200e-9 ad=33.15e-15 as=33.15e-15 pd=730e-9 ps=730e-9 nrd=647.059e-3 nrs=647.059e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 ns s inh_ground inh_ground nch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net055 d inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net139 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net139 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1024 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 ns s inh_power inh_power pch l=60e-9 w=470e-9 m=1 nf=1 sd=200e-9 ad=91.65e-15 as=91.65e-15 pd=1.33e-6 ps=1.33e-6 nrd=234.043e-3 nrs=234.043e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa106 bclk nclk inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen034 nm bclk net055 inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net055 d inh_power inh_power pch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1026 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1017 m r p1 inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net123 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net129 ns net123 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net129 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQNX3MA10TR
** View name: schematic
.subckt DFFRPQNX3MA10TR ck d qn r inh_ground inh_power
mna1 net37 s inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 bclk nclk inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe014 nm nclk net092 inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1034 m r inh_ground inh_ground nch l=60e-9 w=400e-9 m=1 nf=1 sd=200e-9 ad=78e-15 as=78e-15 pd=1.19e-6 ps=1.19e-6 nrd=275e-3 nrs=275e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe018 s bclk m inh_ground nch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 net092 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna108 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net53 net37 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net53 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1022 nclk ck inh_ground inh_ground nch l=60e-9 w=280e-9 m=1 nf=1 sd=200e-9 ad=54.6e-15 as=54.6e-15 pd=950e-9 ps=950e-9 nrd=392.857e-3 nrs=392.857e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1030 qn s inh_ground inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen016 nm bclk net092 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm nclk p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net37 s inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 bclk nclk inh_power inh_power pch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen020 s nclk m inh_power pch l=60e-9 w=570e-9 m=1 nf=1 sd=200e-9 ad=111.15e-15 as=111.15e-15 pd=1.53e-6 ps=1.53e-6 nrd=192.983e-3 nrs=192.983e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 net092 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1037 m r p1_12 inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_12 nm inh_power inh_power pch l=60e-9 w=800e-9 m=1 nf=1 sd=200e-9 ad=156e-15 as=156e-15 pd=1.99e-6 ps=1.99e-6 nrd=137.5e-3 nrs=137.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1010 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1024 nclk ck inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1032 qn s inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net36 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net39 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net36 net37 net39 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQNX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: DFFRPQX3MA10TR
** View name: schematic
.subckt DFFRPQX3MA10TR ck d q r inh_ground inh_power
mna105 bclk nclk inh_ground inh_ground nch l=60e-9 w=210e-9 m=1 nf=1 sd=200e-9 ad=40.95e-15 as=40.95e-15 pd=810e-9 ps=810e-9 nrd=523.81e-3 nrs=523.81e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe028 nm nclk net055 inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn3 s r inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe s bclk m inh_ground nch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1032 ns s inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1010 m r inh_ground inh_ground nch l=60e-9 w=430e-9 m=1 nf=1 sd=200e-9 ad=83.85e-15 as=83.85e-15 pd=1.25e-6 ps=1.25e-6 nrd=255.814e-3 nrs=255.814e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 m nm inh_ground inh_ground nch l=60e-9 w=430e-9 m=1 nf=1 sd=200e-9 ad=83.85e-15 as=83.85e-15 pd=1.25e-6 ps=1.25e-6 nrd=255.814e-3 nrs=255.814e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 nclk ck inh_ground inh_ground nch l=60e-9 w=240e-9 m=1 nf=1 sd=200e-9 ad=46.8e-15 as=46.8e-15 pd=870e-9 ps=870e-9 nrd=458.333e-3 nrs=458.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1036 net055 d inh_ground inh_ground nch l=60e-9 w=580e-9 m=1 nf=1 sd=200e-9 ad=113.1e-15 as=113.1e-15 pd=1.55e-6 ps=1.55e-6 nrd=189.655e-3 nrs=189.655e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1040 q ns inh_ground inh_ground nch l=60e-9 w=1.74e-6 m=1 nf=1 sd=200e-9 ad=339.3e-15 as=339.3e-15 pd=3.87e-6 ps=3.87e-6 nrd=63.2184e-3 nrs=63.2184e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn2 net140 ns inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn4 s nclk net140 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 n1 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe024 nm bclk n1 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1034 ns s inh_power inh_power pch l=60e-9 w=680e-9 m=1 nf=1 sd=200e-9 ad=132.6e-15 as=132.6e-15 pd=1.75e-6 ps=1.75e-6 nrd=161.765e-3 nrs=161.765e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen s nclk m inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa107 bclk nclk inh_power inh_power pch l=60e-9 w=420e-9 m=1 nf=1 sd=200e-9 ad=81.9e-15 as=81.9e-15 pd=1.23e-6 ps=1.23e-6 nrd=261.905e-3 nrs=261.905e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen030 nm bclk net055 inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 nclk ck inh_power inh_power pch l=60e-9 w=300e-9 m=1 nf=1 sd=200e-9 ad=58.5e-15 as=58.5e-15 pd=990e-9 ps=990e-9 nrd=366.667e-3 nrs=366.667e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1038 net055 d inh_power inh_power pch l=60e-9 w=500e-9 m=1 nf=1 sd=200e-9 ad=97.5e-15 as=97.5e-15 pd=1.39e-6 ps=1.39e-6 nrd=220e-3 nrs=220e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1042 q ns inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1022 p1_12 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen026 nm nclk p1_12 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1013 m r p1 inh_power pch l=60e-9 w=850e-9 m=1 nf=1 sd=200e-9 ad=165.75e-15 as=165.75e-15 pd=2.09e-6 ps=2.09e-6 nrd=129.412e-3 nrs=129.412e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1 nm inh_power inh_power pch l=60e-9 w=850e-9 m=1 nf=1 sd=200e-9 ad=165.75e-15 as=165.75e-15 pd=2.09e-6 ps=2.09e-6 nrd=129.412e-3 nrs=129.412e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp5 net124 r inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp2 net118 ns net124 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp3 s bclk net118 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends DFFRPQX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: PREICGX1BA10TR
** View name: schematic
.subckt PREICGX1BA10TR ck e eck se inh_ground inh_power
mn1 n1 m inh_ground inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1026 eck nout inh_ground inh_ground nch l=60e-9 w=360e-9 m=1 nf=1 sd=200e-9 ad=70.2e-15 as=70.2e-15 pd=1.11e-6 ps=1.11e-6 nrd=305.556e-3 nrs=305.556e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1012 nclk_ ck inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe nm nclk_ nen inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1016 m nm inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 nout ck n1 inh_ground nch l=60e-9 w=180e-9 m=1 nf=1 sd=200e-9 ad=35.1e-15 as=35.1e-15 pd=750e-9 ps=750e-9 nrd=611.111e-3 nrs=611.111e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 n1_6 m inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnoe05 nm ck n1_6 inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna2 nen se inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1020 nen e inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen nm ck nen inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1028 eck nout inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1018 m nm inh_power inh_power pch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 nout ck inh_power inh_power pch l=60e-9 w=220e-9 m=1 nf=1 sd=200e-9 ad=42.9e-15 as=42.9e-15 pd=830e-9 ps=830e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1014 nclk_ ck inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 nout m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 p1 m inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpoen07 nm nclk_ p1 inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1023 nen e p1_9 inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa2 p1_9 se inh_power inh_power pch l=60e-9 w=560e-9 m=1 nf=1 sd=200e-9 ad=109.2e-15 as=109.2e-15 pd=1.51e-6 ps=1.51e-6 nrd=196.429e-3 nrs=196.429e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends PREICGX1BA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX1BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX3BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
** View name: schematic
.subckt SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0 clk en enclk te inh_ground inh_power
xlatch clk en enclk te inh_ground inh_power PREICGX2BA10TR
.ends SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: INVX3MA10TR
** View name: schematic
.subckt INVX3MA10TR a y inh_ground inh_power
mna1 y a inh_ground inh_ground nch l=60e-9 w=1.59e-6 m=1 nf=1 sd=200e-9 ad=310.05e-15 as=310.05e-15 pd=3.57e-6 ps=3.57e-6 nrd=69.1824e-3 nrs=69.1824e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y a inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends INVX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFHX1MA10TR
** View name: schematic
.subckt BUFHX1MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=340e-9 m=1 nf=1 sd=200e-9 ad=66.3e-15 as=66.3e-15 pd=1.07e-6 ps=1.07e-6 nrd=323.529e-3 nrs=323.529e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=530e-9 m=1 nf=1 sd=200e-9 ad=103.35e-15 as=103.35e-15 pd=1.45e-6 ps=1.45e-6 nrd=207.547e-3 nrs=207.547e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=450e-9 m=1 nf=1 sd=200e-9 ad=87.75e-15 as=87.75e-15 pd=1.29e-6 ps=1.29e-6 nrd=244.444e-3 nrs=244.444e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFHX1MA10TR
** End of subcircuit definition.

** Library name: gds_lib
** Cell name: adc_cap_dac_8_bit_diff_sar_control_diff_w_regs
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_sar_control_diff_w_regs clk rst adc_en calib_en comp_result s_c dac_switches_top_0<1> dac_switches_top_0<0> dac_switches_bot_0<1> dac_switches_bot_0<0> dac_switches_top_1<1> dac_switches_top_1<0> dac_switches_bot_1<1> dac_switches_bot_1<0> dac_switches_top_2<1> dac_switches_top_2<0> dac_switches_bot_2<1> dac_switches_bot_2<0> dac_switches_top_3<1> dac_switches_top_3<0> dac_switches_bot_3<1> dac_switches_bot_3<0> dac_switches_top_4<1> dac_switches_top_4<0> dac_switches_bot_4<1> dac_switches_bot_4<0> dac_switches_top_5<1> dac_switches_top_5<0> dac_switches_bot_5<1> dac_switches_bot_5<0> dac_switches_top_6<1> dac_switches_top_6<0> dac_switches_bot_6<1> dac_switches_bot_6<0> dac_switches_top_7<1> dac_switches_top_7<0> dac_switches_bot_7<1> dac_switches_bot_7<0> dummy_switch_top<1> dummy_switch_top<0> dummy_switch_bot<1> dummy_switch_bot<0> eoc_n load_reg reg_wdata<7> reg_wdata<6> reg_wdata<5> reg_wdata<4> reg_wdata<3> reg_wdata<2> reg_wdata<1> reg_wdata<0> cn_3__bar cn_2_ cn_0_
+cn_1__bar cp_3__bar cp_1_ cp_0_ cp_2__bar ltielo_net clk_clone1 inh_ground inh_power
vthru0 fe_rn_5 dac_switches_bot_0<0> DC=0
vthru1 fe_rn_6 reg_wdata<1> DC=0
vthru2 dac_switches_top_2<0> reg_wdata<2> DC=0
vthru3 dac_switches_top_3<0> reg_wdata<3> DC=0
vthru4 dac_switches_top_4<0> reg_wdata<4> DC=0
vthru5 dac_switches_top_5<0> reg_wdata<5> DC=0
vthru6 dac_switches_top_6<0> reg_wdata<6> DC=0
vthru7 dac_switches_top_7<0> reg_wdata<7> DC=0
vthru8 fe_rn_8 dummy_switch_bot<0> DC=0
vthru9 fe_rn_7 dummy_switch_bot<1> DC=0
xu177 n123 n122 n121 adc_en n141 inh_ground inh_power NAND4XXXBX0P5MA10TR
xu187 n172 n171 n170 n173 cn_next<1> inh_ground inh_power NAND4XXXBX0P5MA10TR
xu101 n33 n42 n41 n40 n130 inh_ground inh_power NAND4X0P5MA10TR
xu138 n172 n69 n68 fe_phn50_n67 cn_next<2> inh_ground inh_power NAND4X0P5MA10TR
xu186 fe_phn45_off_bit fe_phn22_fe_rn_3 cn_0_ n143 n170 inh_ground inh_power NAND4X0P5MA10TR
xu5 n90 reg_wdata<0> comp_result fe_phn45_off_bit n35 inh_ground inh_power OAI22X0P5MA10TR
xu60 n27 n120 n24 n20 n152 inh_ground inh_power OAI22X0P5MA10TR
xu99 fe_phn40_n6 n49 n38 n37 n39 inh_ground inh_power OAI22X0P5MA10TR
xu145 n110 n70 fe_phn44_fe_rn_1 n108 n81 inh_ground inh_power OAI22X0P5MA10TR
xu153 n113 n89 n78 n33 n80 inh_ground inh_power OAI22X0P5MA10TR
xu185 fe_phn22_fe_rn_3 n169 n168 n167 n173 inh_ground inh_power OAI22X0P5MA10TR
xu168 fe_phn22_fe_rn_3 n100 n99 n164 n102 inh_ground inh_power ADDFX1MA10TR
xu184 n166 n165 n164 n66 n168 inh_ground inh_power ADDFX1MA10TR
xu154 cp_2__bar n80 fe_phn44_fe_rn_1 n79 n105 n87 inh_ground inh_power AOI221X0P5MA10TR
xu171 n163 cp_0_ n162 n104 n103 n119 inh_ground inh_power AOI221X0P5MA10TR
xu183 n163 cn_0_ n162 n161 n160 n169 inh_ground inh_power AOI221X0P5MA10TR
xu182 fe_phn48_n158 n11 n157 n138 inh_ground inh_power OAI2XB1X0P5MA10TR
xu181 n11 n156 n1470 n1460 inh_ground inh_power AOI21BX0P5MA10TR
xu163 cp_0_ n103 n105 n97 inh_ground inh_power AOI21X0P5MA10TR
xu180 n11 n155 n154 n1470 inh_ground inh_power AOI21X0P5MA10TR
xu179 n1450 n132 n1440 inh_ground inh_power AND2X0P5MA10TR
xu178 n124 n154 n1480 inh_ground inh_power NOR2BX0P5MA10TR
xu126 n163 fe_phn47_cn_2 n58 n53 n570 inh_ground inh_power AOI211X0P5MA10TR
xu176 comp_result n155 fe_phn33_n8 n120 n153 inh_ground inh_power AOI211X0P5MA10TR
xu15 n121 n22 n18 n124 n127 inh_ground inh_power OAI211X0P5MA10TR
xu51 n12 n20 n28 n19 n1500 inh_ground inh_power OAI211X0P5MA10TR
xu53 fe_phn33_n8 n20 n13 n19 n1490 inh_ground inh_power OAI211X0P5MA10TR
xu67 n18 reg_wdata<0> n157 n124 n131 inh_ground inh_power OAI211X0P5MA10TR
xu70 n22 n38 n21 n57 n126 inh_ground inh_power OAI211X0P5MA10TR
xu75 n24 n29 n157 n132 n135 inh_ground inh_power OAI211X0P5MA10TR
xu77 n40 reg_wdata<0> n157 n25 n133 inh_ground inh_power OAI211X0P5MA10TR
xu79 n27 n29 n157 n26 n137 inh_ground inh_power OAI211X0P5MA10TR
xu80 n155 n29 n157 n28 n136 inh_ground inh_power OAI211X0P5MA10TR
xu120 n48 n47 n46 n71 n129 inh_ground inh_power OAI211X0P5MA10TR
xu132 fe_phn71_fe_rn_4 n570 n56 n172 cn_next<3> inh_ground inh_power OAI211X0P5MA10TR
xu137 n66 n65 n112 n64 n67 inh_ground inh_power OAI211X0P5MA10TR
xu151 fe_phn44_fe_rn_1 n76 n75 n74 cp_next<3> inh_ground inh_power OAI211X0P5MA10TR
xu157 fe_rn_2 n85 n112 n84 n86 inh_ground inh_power OAI211X0P5MA10TR
xu158 n89 n88 n87 n86 cp_next<2> inh_ground inh_power OAI211X0P5MA10TR
xu166 n95 n94 n112 n93 n96 inh_ground inh_power OAI211X0P5MA10TR
xu167 cp_0_ n98 n97 n96 cp_next<0> inh_ground inh_power OAI211X0P5MA10TR
xu170 n102 n167 n101 n172 cn_next<0> inh_ground inh_power OAI211X0P5MA10TR
xu175 n119 n118 n116 n115 cp_next<1> inh_ground inh_power OAI211X0P5MA10TR
xu6 fe_phn44_fe_rn_1 n108 fe_phn23_cp_store_2 cp_2__bar n109 inh_ground inh_power AOI22X0P5MA10TR
xu7 fe_phn46_fe_rn_4 fe_phn29_cn_store_3 n63 cn_3__bar n65 inh_ground inh_power AOI22X0P5MA10TR
xu17 fe_phn53_n32 fe_phn26_n114 n161 n45 n144 inh_ground inh_power AOI22X0P5MA10TR
xu35 fe_phn32_n5 n44 n23 n37 n128 inh_ground inh_power AOI22X0P5MA10TR
xu39 n10 reg_wdata<0> n90 n42 n125 inh_ground inh_power AOI22X0P5MA10TR
xu57 n11 n44 n154 reg_wdata<0> n15 inh_ground inh_power AOI22X0P5MA10TR
xu104 fe_phn53_n32 n100 fe_phn22_fe_rn_3 n45 n145 inh_ground inh_power AOI22X0P5MA10TR
xu106 fe_phn53_n32 n82 fe_rn_2 n45 n151 inh_ground inh_power AOI22X0P5MA10TR
xu108 fe_phn53_n32 n108 fe_phn44_fe_rn_1 n45 n150 inh_ground inh_power AOI22X0P5MA10TR
xu110 fe_phn53_n32 n63 fe_phn46_fe_rn_4 n45 n147 inh_ground inh_power AOI22X0P5MA10TR
xu113 fe_phn53_n32 n92 n118 n45 n149 inh_ground inh_power AOI22X0P5MA10TR
xu115 fe_phn53_n32 n165 n166 n45 n146 inh_ground inh_power AOI22X0P5MA10TR
xu117 fe_phn53_n32 fe_phn25_n117 n104 n45 n148 inh_ground inh_power AOI22X0P5MA10TR
xu130 n55 n162 n112 n54 n56 inh_ground inh_power AOI22X0P5MA10TR
xu155 n83 cp_store<3> n82 n81 n85 inh_ground inh_power AOI22X0P5MA10TR
xu164 cp_1_ fe_phn24_cp_store_1 n92 n118 n94 inh_ground inh_power AOI22X0P5MA10TR
xu169 cn_0_ n160 n103 n161 n101 inh_ground inh_power AOI22X0P5MA10TR
xu174 n113 n163 n112 n111 n115 inh_ground inh_power AOI22X0P5MA10TR
xu173 n110 n109 n111 inh_ground inh_power XNOR2X0P5MA10TR
xu96 fe_phn46_fe_rn_4 n59 n166 n35 n36 inh_ground inh_power AOI31X0P5MA10TR
xu118 calib_en n122 n44 n50 n46 inh_ground inh_power AOI31X0P5MA10TR
xu147 n112 cp_store<3> n81 n105 n75 inh_ground inh_power AOI31X0P5MA10TR
xu172 n106 n143 n118 n105 n116 inh_ground inh_power AOI31X0P5MA10TR
xu11 n9 n155 n14 inh_ground inh_power NAND2X0P5BA10TR
xu13 n22 fe_phn40_n6 n21 inh_ground inh_power NAND2X0P5BA10TR
xu19 n48 fe_phn32_n5 n17 inh_ground inh_power NAND2X0P5BA10TR
xu21 fe_phn33_n8 fe_phn42_n7 n24 inh_ground inh_power NAND2X0P5BA10TR
xu23 fe_phn32_n5 n123 n22 inh_ground inh_power NAND2X0P5BA10TR
xu29 n16 n14 dummy_switch_bot_next_0_ inh_ground inh_power NAND2X0P5BA10TR
xu32 n48 n37 n52 inh_ground inh_power NAND2X0P5BA10TR
xu43 fe_phn40_n6 fe_phn32_n5 n120 inh_ground inh_power NAND2X0P5BA10TR
xu44 n50 n122 n40 inh_ground inh_power NAND2X0P5BA10TR
xu48 n11 reg_wdata<0> n20 inh_ground inh_power NAND2X0P5BA10TR
xu49 n123 n11 n28 inh_ground inh_power NAND2X0P5BA10TR
xu50 n122 n24 n19 inh_ground inh_power NAND2X0P5BA10TR
xu52 fe_phn42_n7 n11 n13 inh_ground inh_power NAND2X0P5BA10TR
xu58 n15 n19 n139 inh_ground inh_power NAND2X0P5BA10TR
xu63 n11 n23 n124 inh_ground inh_power NAND2X0P5BA10TR
xu65 n21 n57 n140 inh_ground inh_power NAND2X0P5BA10TR
xu69 adc_en n121 n38 inh_ground inh_power NAND2X0P5BA10TR
xu73 comp_result n11 n29 inh_ground inh_power NAND2X0P5BA10TR
xu74 n122 n23 n132 inh_ground inh_power NAND2X0P5BA10TR
xu76 n156 n122 n25 inh_ground inh_power NAND2X0P5BA10TR
xu78 n156 n11 n26 inh_ground inh_power NAND2X0P5BA10TR
xu88 cp_1_ n106 n77 inh_ground inh_power NAND2X0P5BA10TR
xu94 fe_phn44_fe_rn_1 n113 n88 inh_ground inh_power NAND2X0P5BA10TR
xu119 n143 n45 n71 inh_ground inh_power NAND2X0P5BA10TR
xu133 n59 n163 n171 inh_ground inh_power NAND2X0P5BA10TR
xu135 n166 n61 n68 inh_ground inh_power NAND2X0P5BA10TR
xu136 n66 n65 n64 inh_ground inh_power NAND2X0P5BA10TR
xu156 fe_rn_2 n85 n84 inh_ground inh_power NAND2X0P5BA10TR
xu165 n95 n94 n93 inh_ground inh_power NAND2X0P5BA10TR
xu8 n59 n89 n58 inh_ground inh_power NOR2X0P5AA10TR
xu14 n47 n17 load_reg inh_ground inh_power NOR2X0P5AA10TR
xu36 n24 fe_phn40_n6 n10 inh_ground inh_power NOR2X0P5AA10TR
xu45 comp_result n40 dac_switches_top_next_7_0_ inh_ground inh_power NOR2X0P5AA10TR
xu46 fe_phn32_n5 n48 n11 inh_ground inh_power NOR2X0P5AA10TR
xu54 n156 n50 n27 inh_ground inh_power NOR2X0P5AA10TR
xu59 n11 n154 n1450 inh_ground inh_power NOR2X0P5AA10TR
xu83 n166 n60 n55 inh_ground inh_power NOR2X0P5AA10TR
xu87 fe_phn45_off_bit n104 n106 inh_ground inh_power NOR2X0P5AA10TR
xu98 fe_phn32_n5 n51 n49 inh_ground inh_power NOR2X0P5AA10TR
xu129 n66 n63 n54 inh_ground inh_power NOR2X0P5AA10TR
xu139 n77 n33 n79 inh_ground inh_power NOR2X0P5AA10TR
xu144 fe_phn23_cp_store_2 cp_2__bar n70 inh_ground inh_power NOR2X0P5AA10TR
xu159 n162 n163 n91 inh_ground inh_power NOR2X0P5AA10TR
xu160 fe_phn45_off_bit n91 n160 inh_ground inh_power NOR2X0P5AA10TR
xu162 n91 n90 n103 inh_ground inh_power NOR2X0P5AA10TR
xu9 n120 n122 inh_ground inh_power INVX0P5BA10TR
xu12 fe_phn47_cn_2 n166 inh_ground inh_power INVX0P5BA10TR
xu18 fe_phn40_n6 n48 inh_ground inh_power INVX0P5BA10TR
xu22 n24 n123 inh_ground inh_power INVX0P5BA10TR
xu24 fe_phn32_n5 n37 inh_ground inh_power INVX0P5BA10TR
xu26 n23 n44 inh_ground inh_power INVX0P5BA10TR
xu28 n17 n9 inh_ground inh_power INVX0P5BA10TR
xu31 n156 n47 inh_ground inh_power INVX0P5BA10TR
xu37 fe_phn77_off_bit n90 inh_ground inh_power INVX0P5BA10TR
xu38 n10 n42 inh_ground inh_power INVX0P5BA10TR
xu40 n21 dac_switches_top_next_0<0> inh_ground inh_power INVX0P5BA10TR
xu41 fe_phn33_n8 n12 inh_ground inh_power INVX0P5BA10TR
xu61 calib_en n121 inh_ground inh_power INVX0P5BA10TR
xu62 dac_switches_top_next_0<1> n18 inh_ground inh_power INVX0P5BA10TR
xu64 n154 n57 inh_ground inh_power INVX0P5BA10TR
xu85 n35 n31 inh_ground inh_power INVX0P5BA10TR
xu86 cp_0_ n104 inh_ground inh_power INVX0P5BA10TR
xu102 fe_phn28_cn_store_1 n100 inh_ground inh_power INVX0P5BA10TR
xu105 cp_store<3> n82 inh_ground inh_power INVX0P5BA10TR
xu107 fe_phn23_cp_store_2 n108 inh_ground inh_power INVX0P5BA10TR
xu109 fe_phn29_cn_store_3 n63 inh_ground inh_power INVX0P5BA10TR
xu111 fe_phn24_cp_store_1 n92 inh_ground inh_power INVX0P5BA10TR
xu112 cp_1_ n118 inh_ground inh_power INVX0P5BA10TR
xu114 fe_phn27_cn_store_2 n165 inh_ground inh_power INVX0P5BA10TR
xu116 cn_0_ n161 inh_ground inh_power INVX0P5BA10TR
xu127 n33 n162 inh_ground inh_power INVX0P5BA10TR
xu128 n167 n112 inh_ground inh_power INVX0P5BA10TR
xu140 n79 n76 inh_ground inh_power INVX0P5BA10TR
xu148 n81 n83 inh_ground inh_power INVX0P5BA10TR
xu152 n77 n78 inh_ground inh_power INVX0P5BA10TR
xu161 n160 n98 inh_ground inh_power INVX0P5BA10TR
xu10 n162 fe_phn47_cn_2 n60 n58 fe_phn47_cn_2 n69 inh_ground inh_power AOI32X0P5MA10TR
xu125 n66 n33 n63 n167 n33 n53 inh_ground inh_power AOI32X0P5MA10TR
xu149 n83 n33 n82 n167 n33 n72 inh_ground inh_power AOI32X0P5MA10TR
xu150 n163 cp_3__bar n88 n72 cp_3__bar n74 inh_ground inh_power AOI32X0P5MA10TR
xu25 fe_phn33_n8 fe_phn42_n7 n23 inh_ground inh_power NOR2X0P7MA10TR
xu141 fe_phn25_n117 n104 n95 inh_ground inh_power NOR2X0P7MA10TR
xu146 fe_phn45_off_bit n71 n105 inh_ground inh_power NOR2X0P7MA10TR
xu142 cp_1_ fe_phn24_cp_store_1 cp_1_ n95 fe_phn24_cp_store_1 n95 n110 inh_ground inh_power AOI222X0P5MA10TR
xu16 n156 n17 n16 dac_switches_top_next_0<1> inh_ground inh_power OAI21X0P5MA10TR
xu55 n27 n52 n14 n142 inh_ground inh_power OAI21X0P5MA10TR
xu68 n20 n47 n19 n1510 inh_ground inh_power OAI21X0P5MA10TR
xu71 comp_result fe_phn33_n8 n155 n158 inh_ground inh_power OAI21X0P5MA10TR
xu72 n120 fe_phn48_n158 n157 n134 inh_ground inh_power OAI21X0P5MA10TR
xu97 cp_3__bar n88 n36 n51 inh_ground inh_power OAI21X0P5MA10TR
xu100 n11 n39 fe_phn33_n8 n41 inh_ground inh_power OAI21X0P5MA10TR
xu134 n60 n33 n171 n61 inh_ground inh_power OAI21X0P5MA10TR
xu123 fe_phn26_n114 cn_0_ n99 inh_ground inh_power NAND2BX0P5MA10TR
xu131 n71 fe_phn77_off_bit n172 inh_ground inh_power NAND2BX0P5MA10TR
xu124 n52 n51 n50 n167 inh_ground inh_power NAND3BX0P7MA10TR
xu20 fe_phn42_n7 n155 inh_ground inh_power INVX0P7BA10TR
xu34 comp_result reg_wdata<0> inh_ground inh_power INVX0P7BA10TR
xu66 dummy_switch_bot_next_0_ n157 inh_ground inh_power INVX0P7BA10TR
xu103 fe_phn53_n32 n45 inh_ground inh_power INVX0P7BA10TR
xu122 n89 n163 inh_ground inh_power INVX0P7BA10TR
xu27 n48 n37 n44 n16 inh_ground inh_power NAND3X0P5MA10TR
xu82 fe_phn45_off_bit cn_0_ cn_1__bar n60 inh_ground inh_power NAND3X0P5MA10TR
xu121 n50 n49 n48 n89 inh_ground inh_power NAND3X0P5MA10TR
xu4 fe_phn45_off_bit cp_0_ cp_1_ n113 inh_ground inh_power NOR3X0P7MA10TR
xu95 cn_0_ cn_1__bar n90 n59 inh_ground inh_power NOR3X0P7MA10TR
xu92 n32 n143 n33 inh_ground inh_power NAND2X0P7BA10TR
xu90 n55 cn_3__bar n31 fe_phn79_n30 n32 inh_ground inh_power AOI211X1MA10TR
xu89 fe_phn44_fe_rn_1 fe_rn_2 n77 n30 inh_ground inh_power NOR3X0P5AA10TR
xu30 n155 fe_phn33_n8 n156 inh_ground inh_power NOR2X1MA10TR
xu33 n47 n52 n143 inh_ground inh_power NOR2X1MA10TR
xu42 fe_phn42_n7 n12 n50 inh_ground inh_power NOR2X1MA10TR
xu56 n24 n17 n154 inh_ground inh_power NOR2X1MA10TR
xu3 n17 n155 n21 eoc_n inh_ground inh_power OAI21X1MA10TR
xcp_store_reg_0_ net349 fe_phn60_n148 n117 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xcn_store_reg_0_ net349 fe_phn54_n144 n114 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xcn_reg_3_ net344 fe_phn82_cn_next_3 fe_rn_4 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xcp_reg_3_ net344 fe_phn83_cp_next_3 fe_rn_2 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xcn_reg_1_ net344 fe_phn56_cn_next_1 fe_rn_3 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xc_state_reg_3_ net354 n127 n6 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xc_state_reg_1_ net354 n129 n7 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xcp_reg_2_ net344 fe_phn61_cp_next_2 fe_rn_1 rst inh_ground inh_power DFFRPQNX1MA10TR
xc_state_reg_0_ net354 n130 n8 rst inh_ground inh_power DFFRPQNX1MA10TR
xc_state_reg_2_ net354 n128 n5 rst inh_ground inh_power DFFRPQNX1MA10TR
xcn_reg_0_ net344 fe_phn65_cn_next_0 cn_0_ rst inh_ground inh_power DFFRPQX2MA10TR
xcp_reg_1_ net344 fe_phn63_cp_next_1 cp_1_ rst inh_ground inh_power DFFRPQX2MA10TR
xcp_reg_0_ net344 fe_phn66_cp_next_0 cp_0_ rst inh_ground inh_power DFFRPQX2MA10TR
xcn_reg_2_ net344 cn_next<2> cn_2_ rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_7_reg_0_ net339 dac_switches_top_next_7_0_ dac_switches_top_7<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_2_reg_0_ net313 n1490 dac_switches_top_2<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_3_reg_0_ net319 n1500 dac_switches_top_3<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_4_reg_0_ net324 n1510 dac_switches_top_4<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_5_reg_0_ net329 n152 dac_switches_top_5<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_6_reg_0_ net334 n153 dac_switches_top_6<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_7_reg_1_ net339 n133 dac_switches_top_7<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_5_reg_1_ net329 n135 dac_switches_top_5<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_4_reg_1_ net324 n136 dac_switches_top_4<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_3_reg_1_ net319 n137 dac_switches_top_3<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_bot_2_reg_0_ net313 n138 dac_switches_bot_2<0> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_2_reg_1_ net313 n138 dac_switches_top_2<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_bot_2_reg_1_ net313 n1490 dac_switches_bot_2<1> rst inh_ground inh_power DFFRPQX2MA10TR
xdac_switches_top_6_reg_1_ net334 n134 dac_switches_top_6<1> rst inh_ground inh_power DFFRPQX2MA10TR
xoff_bit_reg net313 n125 off_bit rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_6_reg_0_ net334 n134 dac_switches_bot_6<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_6_reg_1_ net334 n153 dac_switches_bot_6<1> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_5_reg_1_ net329 n152 dac_switches_bot_5<1> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_3_reg_0_ net319 n137 dac_switches_bot_3<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_4_reg_0_ net324 n136 dac_switches_bot_4<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_4_reg_1_ net324 n1510 dac_switches_bot_4<1> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_3_reg_1_ net319 n1500 dac_switches_bot_3<1> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_5_reg_0_ net329 n135 dac_switches_bot_5<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_7_reg_0_ net339 n133 dac_switches_bot_7<0> rst inh_ground inh_power DFFRPQX1MA10TR
xdac_switches_bot_7_reg_1_ net339 dac_switches_top_next_7_0_ dac_switches_bot_7<1> rst inh_ground inh_power DFFRPQX1MA10TR
xs_c_reg clk_clone1 fe_phn78_n126 s_c rst inh_ground inh_power DFFRPQNX3MA10TR
xdac_switches_top_1_reg_0_ clk_clone1 n139 fe_rn_6 rst inh_ground inh_power DFFRPQX3MA10TR
xdac_switches_top_1_reg_1_ clk_clone1 n131 dac_switches_top_1<1> rst inh_ground inh_power DFFRPQX3MA10TR
xdummy_switch_top_reg_1_ clk_clone1 dummy_switch_bot_next_0_ fe_rn_8 rst inh_ground inh_power DFFRPQX3MA10TR
xdummy_switch_top_reg_0_ clk_clone1 n140 fe_rn_7 rst inh_ground inh_power DFFRPQX3MA10TR
xdac_switches_bot_0_reg_1_ clk_clone1 dac_switches_top_next_0<0> dac_switches_top_0<0> rst inh_ground inh_power DFFRPQX3MA10TR
xdac_switches_bot_0_reg_0_ clk_clone1 dac_switches_top_next_0<1> fe_rn_5 rst inh_ground inh_power DFFRPQX3MA10TR
xcp_store_reg_3_ net349 fe_phn81_n151 cp_store<3> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcp_store_reg_1_ net349 fe_phn59_n149 cp_store<1> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcp_store_reg_2_ net349 fe_phn80_n150 cp_store<2> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcn_store_reg_3_ net349 fe_phn62_n147 cn_store<3> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcn_store_reg_2_ net349 fe_phn55_n146 cn_store<2> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcn_store_reg_1_ net349 fe_phn64_n145 cn_store<1> rst inh_ground inh_power DFFRPQX0P5MA10TR
xclk_gate_c_state_reg clk n141 net354 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_1
xclk_gate_cn_store_reg clk n143 net349 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_2
xclk_gate_cn_reg clk n142 net344 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_3
xclk_gate_dac_switches_top_7_reg clk n1440 net339 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_4
xclk_gate_dac_switches_top_6_reg clk n1450 net334 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_5
xclk_gate_dac_switches_top_5_reg clk n1460 net329 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_6
xclk_gate_dac_switches_top_4_reg clk n1470 net324 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_7
xclk_gate_dac_switches_top_3_reg clk n1480 net319 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_8
xclk_gate_dac_switches_top_2_reg clk n57 net313 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_sar_control_diff_w_regs_0
xfe_dbtc3_n13 fe_rn_4 cn_3__bar inh_ground inh_power INVX3MA10TR
xfe_dbtc2_n14 fe_rn_3 cn_1__bar inh_ground inh_power INVX3MA10TR
xfe_dbtc1_n15 fe_rn_2 cp_3__bar inh_ground inh_power INVX3MA10TR
xfe_dbtc0_n16 fe_phn44_fe_rn_1 cp_2__bar inh_ground inh_power INVX3MA10TR
xfe_phc82_cn_next_3 cn_next<3> fe_phn82_cn_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc80_n150 n150 fe_phn80_n150 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc76_n7 n7 fe_phn76_n7 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc75_n6 n6 fe_phn75_n6 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc74_n8 n8 fe_phn74_n8 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc73_n5 n5 fe_phn73_n5 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc71_fe_rn_4 fe_phn46_fe_rn_4 fe_phn71_fe_rn_4 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc66_cp_next_0 cp_next<0> fe_phn66_cp_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc65_cn_next_0 cn_next<0> fe_phn65_cn_next_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc64_n145 n145 fe_phn64_n145 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc63_cp_next_1 cp_next<1> fe_phn63_cp_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc62_n147 n147 fe_phn62_n147 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc61_cp_next_2 cp_next<2> fe_phn61_cp_next_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc60_n148 n148 fe_phn60_n148 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc59_n149 n149 fe_phn59_n149 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc58_n151 n151 fe_phn58_n151 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc57_cp_next_3 cp_next<3> fe_phn57_cp_next_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc56_cn_next_1 cn_next<1> fe_phn56_cn_next_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc55_n146 n146 fe_phn55_n146 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc54_n144 n144 fe_phn54_n144 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc50_n67 n67 fe_phn50_n67 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc48_n158 n158 fe_phn48_n158 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc46_fe_rn_4 fe_rn_4 fe_phn46_fe_rn_4 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc45_off_bit off_bit fe_phn45_off_bit inh_ground inh_power DLY4X0P5MA10TR
xfe_phc44_fe_rn_1 fe_rn_1 fe_phn44_fe_rn_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc42_n7 fe_phn76_n7 fe_phn42_n7 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc40_n6 fe_phn75_n6 fe_phn40_n6 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc33_n8 fe_phn74_n8 fe_phn33_n8 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc32_n5 fe_phn73_n5 fe_phn32_n5 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc29_cn_store_3 cn_store<3> fe_phn29_cn_store_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc28_cn_store_1 cn_store<1> fe_phn28_cn_store_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc27_cn_store_2 cn_store<2> fe_phn27_cn_store_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc26_n114 n114 fe_phn26_n114 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc25_n117 n117 fe_phn25_n117 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc24_cp_store_1 cp_store<1> fe_phn24_cp_store_1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc23_cp_store_2 cp_store<2> fe_phn23_cp_store_2 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc22_fe_rn_3 fe_rn_3 fe_phn22_fe_rn_3 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc81_n151 fe_phn58_n151 fe_phn81_n151 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc78_n126 n126 fe_phn78_n126 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc53_n32 n32 fe_phn53_n32 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc47_cn_2 cn_2_ fe_phn47_cn_2 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc83_cp_next_3 fe_phn57_cp_next_3 fe_phn83_cp_next_3 inh_ground inh_power BUFHX1MA10TR
xfe_phc79_n30 n30 fe_phn79_n30 inh_ground inh_power BUFHX1MA10TR
xfe_phc77_off_bit fe_phn45_off_bit fe_phn77_off_bit inh_ground inh_power BUFHX1MA10TR
.ends adc_cap_dac_8_bit_diff_sar_control_diff_w_regs
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFX2MA10TR
** View name: schematic
.subckt BUFX2MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=320e-9 m=1 nf=1 sd=200e-9 ad=62.4e-15 as=62.4e-15 pd=1.03e-6 ps=1.03e-6 nrd=343.75e-3 nrs=343.75e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=1.06e-6 m=1 nf=1 sd=200e-9 ad=206.7e-15 as=206.7e-15 pd=2.51e-6 ps=2.51e-6 nrd=103.774e-3 nrs=103.774e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=420e-9 m=1 nf=1 sd=200e-9 ad=81.9e-15 as=81.9e-15 pd=1.23e-6 ps=1.23e-6 nrd=261.905e-3 nrs=261.905e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=1.4e-6 m=1 nf=1 sd=200e-9 ad=273e-15 as=273e-15 pd=3.19e-6 ps=3.19e-6 nrd=78.5714e-3 nrs=78.5714e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFX2MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: BUFX3MA10TR
** View name: schematic
.subckt BUFX3MA10TR a y inh_ground inh_power
mna1 net15 a inh_ground inh_ground nch l=60e-9 w=480e-9 m=1 nf=1 sd=200e-9 ad=93.6e-15 as=93.6e-15 pd=1.35e-6 ps=1.35e-6 nrd=229.167e-3 nrs=229.167e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna102 y net15 inh_ground inh_ground nch l=60e-9 w=1.59e-6 m=1 nf=1 sd=200e-9 ad=310.05e-15 as=310.05e-15 pd=3.57e-6 ps=3.57e-6 nrd=69.1824e-3 nrs=69.1824e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net15 a inh_power inh_power pch l=60e-9 w=635e-9 m=1 nf=1 sd=200e-9 ad=123.825e-15 as=123.825e-15 pd=1.66e-6 ps=1.66e-6 nrd=173.228e-3 nrs=173.228e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa104 y net15 inh_power inh_power pch l=60e-9 w=2.1e-6 m=1 nf=1 sd=200e-9 ad=409.5e-15 as=409.5e-15 pd=4.59e-6 ps=4.59e-6 nrd=52.381e-3 nrs=52.381e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends BUFX3MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: TIEHIX1MA10TR
** View name: schematic
.subckt TIEHIX1MA10TR y inh_ground inh_power
mn1 lo hi inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn0 lo lo inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 y lo inh_power inh_power pch l=60e-9 w=700e-9 m=1 nf=1 sd=200e-9 ad=136.5e-15 as=136.5e-15 pd=1.79e-6 ps=1.79e-6 nrd=157.143e-3 nrs=157.143e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 hi lo inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends TIEHIX1MA10TR
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: TIELOX1MA10TR
** View name: schematic
.subckt TIELOX1MA10TR y inh_ground inh_power
mn0 y hi inh_ground inh_ground nch l=60e-9 w=550e-9 m=1 nf=1 sd=200e-9 ad=107.25e-15 as=107.25e-15 pd=1.49e-6 ps=1.49e-6 nrd=200e-3 nrs=200e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mn1 lo hi inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp0 hi hi inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mp1 hi lo inh_power inh_power pch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends TIELOX1MA10TR
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc_cap_dac_8_bit_diff_digital_top_verilog
** View name: schematic
.subckt adc_cap_dac_8_bit_diff_digital_top_verilog clk rst firm_en adc_en calib_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> eoc_n comp_result s_c s_c1 dac_switches_top_0<1> dac_switches_top_0<0> dac_switches_bot_0<1> dac_switches_bot_0<0> dac_switches_top_1<1> dac_switches_top_1<0> dac_switches_bot_1<1> dac_switches_bot_1<0> dac_switches_top_2<1> dac_switches_top_2<0> dac_switches_bot_2<1> dac_switches_bot_2<0> dac_switches_top_3<1> dac_switches_top_3<0> dac_switches_bot_3<1> dac_switches_bot_3<0> dac_switches_top_4<1> dac_switches_top_4<0> dac_switches_bot_4<1> dac_switches_bot_4<0> dac_switches_top_5<1> dac_switches_top_5<0> dac_switches_bot_5<1> dac_switches_bot_5<0> dac_switches_top_6<1> dac_switches_top_6<0> dac_switches_bot_6<1> dac_switches_bot_6<0> dac_switches_top_7<1> dac_switches_top_7<0> dac_switches_bot_7<1> dac_switches_bot_7<0> dummy_switch_top<1> dummy_switch_top<0> dummy_switch_bot<1> dummy_switch_bot<0> cn<3> cn<2> cn<1> cn<0> cp<3> cp<2> cp<1> cp<0> vdd! vss! inh_ground inh_power
vthru0 fe_rn_1 s_c DC=0
xfill_t_1_440 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_76 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_67 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_64 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_2 inh_ground inh_power FILLCAP16A10TR
xpcap_200 inh_ground inh_power FILLCAP16A10TR
xpcap_199 inh_ground inh_power FILLCAP16A10TR
xpcap_198 inh_ground inh_power FILLCAP16A10TR
xpcap_197 inh_ground inh_power FILLCAP16A10TR
xpcap_196 inh_ground inh_power FILLCAP16A10TR
xpcap_195 inh_ground inh_power FILLCAP16A10TR
xpcap_194 inh_ground inh_power FILLCAP16A10TR
xpcap_193 inh_ground inh_power FILLCAP16A10TR
xpcap_192 inh_ground inh_power FILLCAP16A10TR
xpcap_191 inh_ground inh_power FILLCAP16A10TR
xpcap_190 inh_ground inh_power FILLCAP16A10TR
xpcap_189 inh_ground inh_power FILLCAP16A10TR
xpcap_188 inh_ground inh_power FILLCAP16A10TR
xpcap_187 inh_ground inh_power FILLCAP16A10TR
xpcap_186 inh_ground inh_power FILLCAP16A10TR
xpcap_185 inh_ground inh_power FILLCAP16A10TR
xpcap_184 inh_ground inh_power FILLCAP16A10TR
xpcap_183 inh_ground inh_power FILLCAP16A10TR
xpcap_182 inh_ground inh_power FILLCAP16A10TR
xpcap_181 inh_ground inh_power FILLCAP16A10TR
xpcap_180 inh_ground inh_power FILLCAP16A10TR
xpcap_179 inh_ground inh_power FILLCAP16A10TR
xpcap_178 inh_ground inh_power FILLCAP16A10TR
xpcap_177 inh_ground inh_power FILLCAP16A10TR
xpcap_176 inh_ground inh_power FILLCAP16A10TR
xpcap_175 inh_ground inh_power FILLCAP16A10TR
xpcap_174 inh_ground inh_power FILLCAP16A10TR
xpcap_173 inh_ground inh_power FILLCAP16A10TR
xpcap_172 inh_ground inh_power FILLCAP16A10TR
xpcap_171 inh_ground inh_power FILLCAP16A10TR
xpcap_170 inh_ground inh_power FILLCAP16A10TR
xpcap_169 inh_ground inh_power FILLCAP16A10TR
xpcap_168 inh_ground inh_power FILLCAP16A10TR
xpcap_167 inh_ground inh_power FILLCAP16A10TR
xpcap_166 inh_ground inh_power FILLCAP16A10TR
xpcap_165 inh_ground inh_power FILLCAP16A10TR
xpcap_164 inh_ground inh_power FILLCAP16A10TR
xpcap_163 inh_ground inh_power FILLCAP16A10TR
xpcap_162 inh_ground inh_power FILLCAP16A10TR
xpcap_161 inh_ground inh_power FILLCAP16A10TR
xpcap_160 inh_ground inh_power FILLCAP16A10TR
xpcap_159 inh_ground inh_power FILLCAP16A10TR
xpcap_158 inh_ground inh_power FILLCAP16A10TR
xpcap_157 inh_ground inh_power FILLCAP16A10TR
xpcap_156 inh_ground inh_power FILLCAP16A10TR
xpcap_155 inh_ground inh_power FILLCAP16A10TR
xpcap_154 inh_ground inh_power FILLCAP16A10TR
xpcap_153 inh_ground inh_power FILLCAP16A10TR
xpcap_152 inh_ground inh_power FILLCAP16A10TR
xpcap_151 inh_ground inh_power FILLCAP16A10TR
xpcap_150 inh_ground inh_power FILLCAP16A10TR
xpcap_149 inh_ground inh_power FILLCAP16A10TR
xpcap_148 inh_ground inh_power FILLCAP16A10TR
xpcap_147 inh_ground inh_power FILLCAP16A10TR
xpcap_146 inh_ground inh_power FILLCAP16A10TR
xpcap_145 inh_ground inh_power FILLCAP16A10TR
xpcap_144 inh_ground inh_power FILLCAP16A10TR
xpcap_143 inh_ground inh_power FILLCAP16A10TR
xpcap_142 inh_ground inh_power FILLCAP16A10TR
xpcap_141 inh_ground inh_power FILLCAP16A10TR
xpcap_140 inh_ground inh_power FILLCAP16A10TR
xpcap_139 inh_ground inh_power FILLCAP16A10TR
xpcap_138 inh_ground inh_power FILLCAP16A10TR
xpcap_137 inh_ground inh_power FILLCAP16A10TR
xpcap_136 inh_ground inh_power FILLCAP16A10TR
xpcap_135 inh_ground inh_power FILLCAP16A10TR
xpcap_134 inh_ground inh_power FILLCAP16A10TR
xpcap_133 inh_ground inh_power FILLCAP16A10TR
xpcap_132 inh_ground inh_power FILLCAP16A10TR
xpcap_131 inh_ground inh_power FILLCAP16A10TR
xpcap_130 inh_ground inh_power FILLCAP16A10TR
xpcap_129 inh_ground inh_power FILLCAP16A10TR
xpcap_128 inh_ground inh_power FILLCAP16A10TR
xpcap_127 inh_ground inh_power FILLCAP16A10TR
xpcap_126 inh_ground inh_power FILLCAP16A10TR
xpcap_125 inh_ground inh_power FILLCAP16A10TR
xpcap_124 inh_ground inh_power FILLCAP16A10TR
xpcap_123 inh_ground inh_power FILLCAP16A10TR
xpcap_122 inh_ground inh_power FILLCAP16A10TR
xpcap_121 inh_ground inh_power FILLCAP16A10TR
xpcap_120 inh_ground inh_power FILLCAP16A10TR
xpcap_119 inh_ground inh_power FILLCAP16A10TR
xpcap_118 inh_ground inh_power FILLCAP16A10TR
xpcap_117 inh_ground inh_power FILLCAP16A10TR
xpcap_116 inh_ground inh_power FILLCAP16A10TR
xpcap_115 inh_ground inh_power FILLCAP16A10TR
xpcap_114 inh_ground inh_power FILLCAP16A10TR
xpcap_113 inh_ground inh_power FILLCAP16A10TR
xpcap_112 inh_ground inh_power FILLCAP16A10TR
xpcap_111 inh_ground inh_power FILLCAP16A10TR
xpcap_110 inh_ground inh_power FILLCAP16A10TR
xpcap_109 inh_ground inh_power FILLCAP16A10TR
xpcap_108 inh_ground inh_power FILLCAP16A10TR
xpcap_107 inh_ground inh_power FILLCAP16A10TR
xpcap_106 inh_ground inh_power FILLCAP16A10TR
xpcap_105 inh_ground inh_power FILLCAP16A10TR
xpcap_104 inh_ground inh_power FILLCAP16A10TR
xpcap_103 inh_ground inh_power FILLCAP16A10TR
xpcap_102 inh_ground inh_power FILLCAP16A10TR
xpcap_101 inh_ground inh_power FILLCAP16A10TR
xpcap_100 inh_ground inh_power FILLCAP16A10TR
xpcap_99 inh_ground inh_power FILLCAP16A10TR
xpcap_98 inh_ground inh_power FILLCAP16A10TR
xpcap_97 inh_ground inh_power FILLCAP16A10TR
xpcap_96 inh_ground inh_power FILLCAP16A10TR
xpcap_95 inh_ground inh_power FILLCAP16A10TR
xpcap_94 inh_ground inh_power FILLCAP16A10TR
xpcap_93 inh_ground inh_power FILLCAP16A10TR
xpcap_92 inh_ground inh_power FILLCAP16A10TR
xpcap_91 inh_ground inh_power FILLCAP16A10TR
xpcap_90 inh_ground inh_power FILLCAP16A10TR
xpcap_89 inh_ground inh_power FILLCAP16A10TR
xpcap_88 inh_ground inh_power FILLCAP16A10TR
xpcap_87 inh_ground inh_power FILLCAP16A10TR
xpcap_86 inh_ground inh_power FILLCAP16A10TR
xpcap_85 inh_ground inh_power FILLCAP16A10TR
xpcap_84 inh_ground inh_power FILLCAP16A10TR
xpcap_83 inh_ground inh_power FILLCAP16A10TR
xpcap_82 inh_ground inh_power FILLCAP16A10TR
xpcap_81 inh_ground inh_power FILLCAP16A10TR
xpcap_80 inh_ground inh_power FILLCAP16A10TR
xpcap_79 inh_ground inh_power FILLCAP16A10TR
xpcap_78 inh_ground inh_power FILLCAP16A10TR
xpcap_77 inh_ground inh_power FILLCAP16A10TR
xpcap_76 inh_ground inh_power FILLCAP16A10TR
xpcap_75 inh_ground inh_power FILLCAP16A10TR
xpcap_74 inh_ground inh_power FILLCAP16A10TR
xpcap_73 inh_ground inh_power FILLCAP16A10TR
xpcap_72 inh_ground inh_power FILLCAP16A10TR
xpcap_71 inh_ground inh_power FILLCAP16A10TR
xpcap_70 inh_ground inh_power FILLCAP16A10TR
xpcap_69 inh_ground inh_power FILLCAP16A10TR
xpcap_68 inh_ground inh_power FILLCAP16A10TR
xpcap_67 inh_ground inh_power FILLCAP16A10TR
xpcap_66 inh_ground inh_power FILLCAP16A10TR
xpcap_65 inh_ground inh_power FILLCAP16A10TR
xpcap_64 inh_ground inh_power FILLCAP16A10TR
xpcap_63 inh_ground inh_power FILLCAP16A10TR
xpcap_62 inh_ground inh_power FILLCAP16A10TR
xpcap_61 inh_ground inh_power FILLCAP16A10TR
xpcap_60 inh_ground inh_power FILLCAP16A10TR
xpcap_59 inh_ground inh_power FILLCAP16A10TR
xpcap_58 inh_ground inh_power FILLCAP16A10TR
xpcap_57 inh_ground inh_power FILLCAP16A10TR
xpcap_56 inh_ground inh_power FILLCAP16A10TR
xpcap_55 inh_ground inh_power FILLCAP16A10TR
xpcap_54 inh_ground inh_power FILLCAP16A10TR
xpcap_53 inh_ground inh_power FILLCAP16A10TR
xpcap_52 inh_ground inh_power FILLCAP16A10TR
xpcap_51 inh_ground inh_power FILLCAP16A10TR
xpcap_50 inh_ground inh_power FILLCAP16A10TR
xpcap_49 inh_ground inh_power FILLCAP16A10TR
xpcap_48 inh_ground inh_power FILLCAP16A10TR
xpcap_47 inh_ground inh_power FILLCAP16A10TR
xpcap_46 inh_ground inh_power FILLCAP16A10TR
xpcap_45 inh_ground inh_power FILLCAP16A10TR
xpcap_44 inh_ground inh_power FILLCAP16A10TR
xpcap_43 inh_ground inh_power FILLCAP16A10TR
xpcap_42 inh_ground inh_power FILLCAP16A10TR
xpcap_41 inh_ground inh_power FILLCAP16A10TR
xpcap_40 inh_ground inh_power FILLCAP16A10TR
xpcap_39 inh_ground inh_power FILLCAP16A10TR
xpcap_38 inh_ground inh_power FILLCAP16A10TR
xpcap_37 inh_ground inh_power FILLCAP16A10TR
xpcap_36 inh_ground inh_power FILLCAP16A10TR
xpcap_35 inh_ground inh_power FILLCAP16A10TR
xpcap_34 inh_ground inh_power FILLCAP16A10TR
xpcap_33 inh_ground inh_power FILLCAP16A10TR
xpcap_32 inh_ground inh_power FILLCAP16A10TR
xpcap_31 inh_ground inh_power FILLCAP16A10TR
xpcap_30 inh_ground inh_power FILLCAP16A10TR
xpcap_29 inh_ground inh_power FILLCAP16A10TR
xpcap_28 inh_ground inh_power FILLCAP16A10TR
xpcap_27 inh_ground inh_power FILLCAP16A10TR
xpcap_26 inh_ground inh_power FILLCAP16A10TR
xpcap_25 inh_ground inh_power FILLCAP16A10TR
xpcap_24 inh_ground inh_power FILLCAP16A10TR
xpcap_23 inh_ground inh_power FILLCAP16A10TR
xpcap_22 inh_ground inh_power FILLCAP16A10TR
xpcap_21 inh_ground inh_power FILLCAP16A10TR
xpcap_20 inh_ground inh_power FILLCAP16A10TR
xpcap_19 inh_ground inh_power FILLCAP16A10TR
xpcap_18 inh_ground inh_power FILLCAP16A10TR
xpcap_17 inh_ground inh_power FILLCAP16A10TR
xpcap_16 inh_ground inh_power FILLCAP16A10TR
xpcap_15 inh_ground inh_power FILLCAP16A10TR
xpcap_14 inh_ground inh_power FILLCAP16A10TR
xpcap_13 inh_ground inh_power FILLCAP16A10TR
xpcap_12 inh_ground inh_power FILLCAP16A10TR
xpcap_11 inh_ground inh_power FILLCAP16A10TR
xpcap_10 inh_ground inh_power FILLCAP16A10TR
xpcap_9 inh_ground inh_power FILLCAP16A10TR
xpcap_8 inh_ground inh_power FILLCAP16A10TR
xpcap_7 inh_ground inh_power FILLCAP16A10TR
xpcap_6 inh_ground inh_power FILLCAP16A10TR
xpcap_5 inh_ground inh_power FILLCAP16A10TR
xpcap_4 inh_ground inh_power FILLCAP16A10TR
xpcap_3 inh_ground inh_power FILLCAP16A10TR
xpcap_2 inh_ground inh_power FILLCAP16A10TR
xpcap_1 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_62 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_60 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_58 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_56 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_54 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_52 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_50 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_48 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_46 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_44 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_42 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_40 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_38 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_36 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_34 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_32 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_30 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_28 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_26 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_24 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_22 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_20 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_18 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_16 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_14 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_12 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_10 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_8 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_6 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_1 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_481 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_472 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_444 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_441 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_365 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_267 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_250 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_203 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_101 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_97 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_83 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_3 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_503 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_487 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_482 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_478 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_477 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_468 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_463 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_460 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_458 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_455 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_434 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_433 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_429 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_425 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_423 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_405 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_403 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_380 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_363 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_355 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_342 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_339 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_304 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_277 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_274 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_273 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_260 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_258 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_254 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_253 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_252 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_238 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_222 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_221 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_216 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_198 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_184 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_170 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_158 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_152 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_126 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_123 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_111 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_105 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_103 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_98 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_90 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_84 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_81 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_79 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_77 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_65 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_4 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_61 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_57 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_53 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_49 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_45 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_41 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_37 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_33 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_29 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_25 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_21 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_17 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_13 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_9 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_476 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_475 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_469 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_464 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_461 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_454 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_443 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_435 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_427 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_417 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_404 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_395 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_385 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_374 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_369 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_357 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_324 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_312 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_290 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_287 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_286 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_244 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_242 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_220 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_218 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_208 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_197 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_196 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_176 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_175 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_172 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_160 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_153 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_136 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_117 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_116 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_110 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_109 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_104 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_99 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_91 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_87 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_85 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_78 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_75 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_74 inh_ground inh_power FILLCAP3A10TR
xu23 firm_en adc_en fe_phn39_dead_adc_en n70 real_adc_en inh_ground inh_power AO22X0P5MA10TR
xu24 firm_en calib_en fe_phn72_dead_calib_en n70 real_calib_en inh_ground inh_power AO22X0P5MA10TR
xu22 fe_phn30_n1 fe_phn67_n8 n60 n6 inh_ground inh_power AOI21X0P5MA10TR
xu17 n60 fe_phn70_n5 fe_phn49_n11 n7 inh_ground inh_power OAI21X0P5MA10TR
xu16 n60 fe_phn70_n5 n11 inh_ground inh_power NAND2X0P5BA10TR
xu13 firm_en n70 inh_ground inh_power INVX0P5BA10TR
xu15 dead_calib_counter_2_ n5 inh_ground inh_power INVX0P5BA10TR
xu14 fe_phn30_n1 fe_phn67_n8 n60 inh_ground inh_power NOR2X0P5AA10TR
xdead_calib_counter_reg_0_ net275 fe_phn84_n1 n1 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xdead_calib_counter_reg_1_ net275 fe_phn51_n6 n8 rst inh_ground inh_power DFFRPQNX0P5MA10TR
xdead_calib_en_reg cts_2 fe_phn49_n11 dead_calib_en rst inh_ground inh_power DFFRPQX0P5MA10TR
xdead_calib_counter_reg_2_ net275 fe_phn52_n7 dead_calib_counter_2_ rst inh_ground inh_power DFFRPQX0P5MA10TR
xdead_adc_en_reg cts_2 ltiehi_net dead_adc_en rst inh_ground inh_power DFFRPQX0P5MA10TR
xclk_gate_dead_calib_counter_reg clk fe_phn49_n11 net275 ltielo_net inh_ground inh_power SNPS_CLOCK_GATE_HIGH_adc_cap_dac_8_bit_diff_digital_top
xadc_regs0 clk rst reg_wdata<7> reg_wdata<6> reg_wdata<5> reg_wdata<4> fe_phn37_dac_switches_top_3_0 reg_wdata<2> dac_switches_top_1<0> reg_wdata<0> load_reg q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> ltielo_net inh_ground inh_power adc_cap_dac_8_bit_diff_adc_regs
xsar_control0 clk rst real_adc_en real_calib_en comp_result fe_rn_1 fe_unconnectedz_0 dac_switches_top_0<0> fe_unconnectedz_1 dac_switches_top_0<1> dac_switches_top_1<1> fe_unconnectedz_2 fe_rn_2 fe_unconnectedz_3 dac_switches_top_2<1> dac_switches_top_2<0> fe_ofn2_dac_switches_bot_2_1 fe_ofn3_dac_switches_bot_2_0 dac_switches_top_3<1> dac_switches_top_3<0> fe_ofn8_dac_switches_bot_3_1 fe_ofn9_dac_switches_bot_3_0 dac_switches_top_4<1> dac_switches_top_4<0> fe_ofn10_dac_switches_bot_4_1 fe_ofn11_dac_switches_bot_4_0 dac_switches_top_5<1> dac_switches_top_5<0> fe_ofn12_dac_switches_bot_5_1 fe_ofn13_dac_switches_bot_5_0 dac_switches_top_6<1> dac_switches_top_6<0> fe_ofn14_dac_switches_bot_6_1 fe_ofn15_dac_switches_bot_6_0 dac_switches_top_7<1> dac_switches_top_7<0> fe_ofn16_dac_switches_bot_7_1 fe_ofn17_dac_switches_bot_7_0 net3<0> net3<1> dummy_switch_bot<1> dummy_switch_bot<0> fe_ofn0_eoc_n load_reg reg_wdata<7> reg_wdata<6> reg_wdata<5> reg_wdata<4> reg_wdata<3> reg_wdata<2> dac_switches_top_1<0>
+reg_wdata<0> cn<3> cn<2> cn<0> cn<1> cp<3> cp<1> cp<0> cp<2> ltielo_net cts_2 inh_ground inh_power adc_cap_dac_8_bit_diff_sar_control_diff_w_regs
xcts_ccl_a_buf_00001 clk cts_2 inh_ground inh_power BUFX2MA10TR
xfe_ofc18_dummy_switch_bot_0 dummy_switch_bot<0> dummy_switch_top<1> inh_ground inh_power BUFX2MA10TR
xfe_ofc17_dummy_switch_bot_1 dummy_switch_bot<1> dummy_switch_top<0> inh_ground inh_power BUFX2MA10TR
xfe_ofc1_s_c s_c s_c1 inh_ground inh_power BUFX2MA10TR
xfe_ofc0_eoc_n fe_ofn0_eoc_n eoc_n inh_ground inh_power BUFX2MA10TR
xfe_ofc3_dac_switches_bot_2_0 fe_ofn3_dac_switches_bot_2_0 dac_switches_bot_2<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc2_dac_switches_bot_2_1 fe_ofn2_dac_switches_bot_2_1 dac_switches_bot_2<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc16_dac_switches_bot_7_0 fe_ofn17_dac_switches_bot_7_0 dac_switches_bot_7<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc15_dac_switches_bot_7_1 fe_ofn16_dac_switches_bot_7_1 dac_switches_bot_7<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc14_dac_switches_bot_6_0 fe_ofn15_dac_switches_bot_6_0 dac_switches_bot_6<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc13_dac_switches_bot_6_1 fe_ofn14_dac_switches_bot_6_1 dac_switches_bot_6<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc12_dac_switches_bot_5_0 fe_ofn13_dac_switches_bot_5_0 dac_switches_bot_5<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc11_dac_switches_bot_5_1 fe_ofn12_dac_switches_bot_5_1 dac_switches_bot_5<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc10_dac_switches_bot_4_0 fe_ofn11_dac_switches_bot_4_0 dac_switches_bot_4<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc9_dac_switches_bot_4_1 fe_ofn10_dac_switches_bot_4_1 dac_switches_bot_4<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc8_dac_switches_bot_3_0 fe_ofn9_dac_switches_bot_3_0 dac_switches_bot_3<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc7_dac_switches_bot_3_1 fe_ofn8_dac_switches_bot_3_1 dac_switches_bot_3<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc5_dac_switches_bot_1_0 dac_switches_top_1<1> dac_switches_bot_1<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc4_dac_switches_bot_1_1 dac_switches_top_1<0> dac_switches_bot_1<1> inh_ground inh_power BUFX3MA10TR
xfe_ofc3_dac_switches_bot_0_0 dac_switches_top_0<1> dac_switches_bot_0<0> inh_ground inh_power BUFX3MA10TR
xfe_ofc2_dac_switches_bot_0_1 dac_switches_top_0<0> dac_switches_bot_0<1> inh_ground inh_power BUFX3MA10TR
xltiehi ltiehi_net inh_ground inh_power TIEHIX1MA10TR
xltielo ltielo_net inh_ground inh_power TIELOX1MA10TR
xfe_phc70_n5 n5 fe_phn70_n5 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc68_n1 fe_phn30_n1 fe_phn68_n1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc67_n8 n8 fe_phn67_n8 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc52_n7 n7 fe_phn52_n7 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc51_n6 n6 fe_phn51_n6 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc49_n11 n11 fe_phn49_n11 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc39_dead_adc_en dead_adc_en fe_phn39_dead_adc_en inh_ground inh_power DLY4X0P5MA10TR
xfe_phc37_dac_switches_top_3_0 reg_wdata<3> fe_phn37_dac_switches_top_3_0 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc31_dead_calib_en dead_calib_en fe_phn31_dead_calib_en inh_ground inh_power DLY4X0P5MA10TR
xfe_phc30_n1 n1 fe_phn30_n1 inh_ground inh_power DLY4X0P5MA10TR
xfe_phc84_n1 fe_phn68_n1 fe_phn84_n1 inh_ground inh_power DLY2X0P5MA10TR
xfe_phc72_dead_calib_en fe_phn31_dead_calib_en fe_phn72_dead_calib_en inh_ground inh_power DLY2X0P5MA10TR
.ends adc_cap_dac_8_bit_diff_digital_top_verilog
** End of subcircuit definition.

** Library name: acadia
** Cell name: adc
** View name: schematic
.subckt adc adc_en ain aip calib_en clk eoc_n ext_opt ext_vdd_half firm_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> rst inh_vdd vdd_half inh_vss real_vdd_half vin vip inh_ground inh_power
xi12 ain aip clk net4<0> net4<1> net4<2> net4<3> net17<0> net17<1> net17<2> net17<3> ext_opt ext_vdd_half net6 net2 net14<0> net14<1> net19<0> net19<1> net20<0> net20<1> net25<0> net25<1> net26<0> net26<1> net28<0> net28<1> net10<0> net10<1> net16<0> net16<1> net15<0> net15<1> net13<0> net13<1> net11<0> net11<1> net31<0> net31<1> net30<0> net30<1> net5<0> net5<1> net3<0> net3<1> net1<0> net1<1> net24<0> net24<1> net23<0> net23<1> net21 net29 inh_vdd vdd_half inh_vss real_vdd_half vin vip adc_cap_dac_8_bit_diff_w_preamp
xi23 clk rst firm_en adc_en calib_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> eoc_n net2 net21 net29 net25<0> net25<1> net20<0> net20<1> net28<0> net28<1> net26<0> net26<1> net16<0> net16<1> net10<0> net10<1> net13<0> net13<1> net15<0> net15<1> net31<0> net31<1> net11<0> net11<1> net5<0> net5<1> net30<0> net30<1> net1<0> net1<1> net3<0> net3<1> net23<0> net23<1> net24<0> net24<1> net19<0> net19<1> net14<0> net14<1> net4<0> net4<1> net4<2> net4<3> net17<0> net17<1> net17<2> net17<3> inh_vdd inh_vss inh_ground inh_power adc_cap_dac_8_bit_diff_digital_top_verilog
.ends adc
** End of subcircuit definition.

** Library name: acadia
** Cell name: CMOS_1_Refs
** View name: schematic
.subckt CMOS_1_Refs vdd vss v_bias v_ref
xm6 net7 net7 vss vss nch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm7 net6 v_ref v_bias vss nch_mac l=2e-6 w=4e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=700e-15 as=700e-15 pd=8.35e-6 ps=8.35e-6 nrd=25e-3 nrs=25e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm9 v_ref v_ref net6 vss nch_mac l=2e-6 w=4e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=700e-15 as=700e-15 pd=8.35e-6 ps=8.35e-6 nrd=25e-3 nrs=25e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm10 v_bias v_ref net32 vss nch_mac l=1e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm4 vbp1 net7 net12 vss nch_mac l=2e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm5 net12 net7 v_bias vss nch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm17 net32 v_ref vss vss nch_mac l=6e-6 w=2e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=350e-15 as=350e-15 pd=4.35e-6 ps=4.35e-6 nrd=50e-3 nrs=50e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0 mismatchflag=1
xm2 vbp1 vbp1 vdd vdd pch_mac l=20e-6 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=1.98981 scb=1.51359e-3 scc=67.1225e-6 mismatchflag=1
xm3 vss v_ref net12 vdd pch_mac l=200e-9 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=10.2513 scb=9.1383e-3 scc=146.598e-6 mismatchflag=1
xm0 net7 vbp1 vdd vdd pch_mac l=10e-6 w=5e-6 multi=1 nf=1 sigma=1 sd=200e-9 ad=875e-15 as=875e-15 pd=10.35e-6 ps=10.35e-6 nrd=20e-3 nrs=20e-3 sa=175e-9 sb=175e-9 sca=2.22864 scb=1.6089e-3 scc=67.9474e-6 mismatchflag=1
xm11 v_ref vbp1 vdd vdd pch_lvt_mac l=4e-6 w=20e-6 multi=3 nf=1 sigma=1 sd=200e-9 ad=3.5e-12 as=3.5e-12 pd=40.35e-6 ps=40.35e-6 nrd=5e-3 nrs=5e-3 sa=175e-9 sb=175e-9 sca=1.60166 scb=831.124e-6 scc=20.6989e-6 mismatchflag=1
.ends CMOS_1_Refs
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: OAI21BX0P5MA10TR
** View name: schematic
.subckt OAI21BX0P5MA10TR a0 a1 b0n y inh_ground inh_power
mna1 net28 b0n inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna106 y net28 n1 inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 n1 a0 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=230e-9 m=1 nf=1 sd=200e-9 ad=44.85e-15 as=44.85e-15 pd=850e-9 ps=850e-9 nrd=478.261e-3 nrs=478.261e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 net28 b0n inh_power inh_power pch l=60e-9 w=200e-9 m=1 nf=1 sd=200e-9 ad=35e-15 as=35e-15 pd=750e-9 ps=750e-9 nrd=500e-3 nrs=500e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 y a0 p1 inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 y net28 inh_power inh_power pch l=60e-9 w=190e-9 m=1 nf=1 sd=200e-9 ad=37.05e-15 as=37.05e-15 pd=770e-9 ps=770e-9 nrd=578.947e-3 nrs=578.947e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends OAI21BX0P5MA10TR
** End of subcircuit definition.

** Library name: dac_gds_lib
** Cell name: dac_thermometer_0
** View name: schematic
.subckt dac_thermometer_0 binary<3> binary<2> binary<1> binary<0> thermometer<14> thermometer<13> thermometer<12> thermometer<11> thermometer<10> thermometer<9> thermometer<8> thermometer<7> thermometer<6> thermometer<5> thermometer<4> thermometer<3> thermometer<2> thermometer<1> thermometer<0> inh_ground inh_power
vthru0 binary<3> thermometer<7> DC=0
xu21 n7 n6 thermometer<5> thermometer<4> inh_ground inh_power OAI21BX0P5MA10TR
xu20 thermometer<13> n7 thermometer<14> inh_ground inh_power NOR2BX0P5MA10TR
xu19 thermometer<1> n7 thermometer<0> inh_ground inh_power NAND2BX0P5MA10TR
xu18 n7 n5 n6 n4 thermometer<8> inh_ground inh_power AOI31X0P5MA10TR
xu15 n7 n5 n2 thermometer<12> inh_ground inh_power AOI21X0P5MA10TR
xu16 n6 n3 n4 thermometer<10> inh_ground inh_power AOI21X0P5MA10TR
xu17 n5 n6 n4 thermometer<9> inh_ground inh_power AOI21X0P5MA10TR
xu1 binary<2> n6 inh_ground inh_power INVX0P5BA10TR
xu2 binary<3> n4 inh_ground inh_power INVX0P5BA10TR
xu4 binary<1> n5 inh_ground inh_power INVX0P5BA10TR
xu10 n2 thermometer<11> inh_ground inh_power INVX0P5BA10TR
xu11 n1 thermometer<3> inh_ground inh_power INVX0P5BA10TR
xu14 binary<0> n7 inh_ground inh_power INVX0P5BA10TR
xu3 binary<2> binary<3> n2 inh_ground inh_power NAND2X0P5BA10TR
xu5 n1 n5 thermometer<1> inh_ground inh_power NAND2X0P5BA10TR
xu12 binary<0> binary<1> n3 inh_ground inh_power NAND2X0P5BA10TR
xu13 n1 n3 thermometer<2> inh_ground inh_power NAND2X0P5BA10TR
xu6 n6 n5 n4 thermometer<5> inh_ground inh_power OAI21X0P5MA10TR
xu9 n6 n3 n4 thermometer<6> inh_ground inh_power OAI21X0P5MA10TR
xu7 n5 n2 thermometer<13> inh_ground inh_power NOR2X0P5AA10TR
xu8 binary<2> binary<3> n1 inh_ground inh_power NOR2X0P5AA10TR
.ends dac_thermometer_0
** End of subcircuit definition.

** Library name: dac_gds_lib
** Cell name: dac_thermometer_1
** View name: schematic
.subckt dac_thermometer_1 binary<3> binary<2> binary<1> binary<0> thermometer<14> thermometer<13> thermometer<12> thermometer<11> thermometer<10> thermometer<9> thermometer<8> thermometer<7> thermometer<6> thermometer<5> thermometer<4> thermometer<3> thermometer<2> thermometer<1> thermometer<0> inh_ground inh_power
vthru0 binary<3> thermometer<7> DC=0
xu21 n7 n6 thermometer<5> thermometer<4> inh_ground inh_power OAI21BX0P5MA10TR
xu20 thermometer<13> n7 thermometer<14> inh_ground inh_power NOR2BX0P5MA10TR
xu19 thermometer<1> n7 thermometer<0> inh_ground inh_power NAND2BX0P5MA10TR
xu18 n7 n5 n6 n4 thermometer<8> inh_ground inh_power AOI31X0P5MA10TR
xu15 n7 n5 n2 thermometer<12> inh_ground inh_power AOI21X0P5MA10TR
xu16 n6 n3 n4 thermometer<10> inh_ground inh_power AOI21X0P5MA10TR
xu17 n5 n6 n4 thermometer<9> inh_ground inh_power AOI21X0P5MA10TR
xu2 binary<2> n6 inh_ground inh_power INVX0P5BA10TR
xu3 binary<3> n4 inh_ground inh_power INVX0P5BA10TR
xu5 binary<1> n5 inh_ground inh_power INVX0P5BA10TR
xu10 n2 thermometer<11> inh_ground inh_power INVX0P5BA10TR
xu11 n1 thermometer<3> inh_ground inh_power INVX0P5BA10TR
xu14 binary<0> n7 inh_ground inh_power INVX0P5BA10TR
xu7 n6 n5 n4 thermometer<5> inh_ground inh_power OAI21X0P5MA10TR
xu13 n6 n3 n4 thermometer<6> inh_ground inh_power OAI21X0P5MA10TR
xu4 binary<2> binary<3> n2 inh_ground inh_power NAND2X0P5BA10TR
xu6 n1 n5 thermometer<1> inh_ground inh_power NAND2X0P5BA10TR
xu9 binary<0> binary<1> n3 inh_ground inh_power NAND2X0P5BA10TR
xu12 n1 n3 thermometer<2> inh_ground inh_power NAND2X0P5BA10TR
xu1 binary<2> binary<3> n1 inh_ground inh_power NOR2X0P5AA10TR
xu8 n5 n2 thermometer<13> inh_ground inh_power NOR2X0P5AA10TR
.ends dac_thermometer_1
** End of subcircuit definition.

** Library name: dac_gds_lib
** Cell name: dac_therm_top
** View name: schematic
.subckt dac_therm_top clk rst dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> rows<14> rows<13> rows<12> rows<11> rows<10> rows<9> rows<8> rows<7> rows<6> rows<5> rows<4> rows<3> rows<2> rows<1> rows<0> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> vdd! vss! inh_ground inh_power
xfill_t_1_322 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_321 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_311 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_310 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_206 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_204 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_202 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_198 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_181 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_140 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_122 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_105 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_103 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_101 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_65 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_55 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_53 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_42 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_40 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_27 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_26 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_24 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_22 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_20 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_13 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_11 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_9 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_7 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_5 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_3 inh_ground inh_power FILLCAP16A10TR
xpcap_12 inh_ground inh_power FILLCAP16A10TR
xpcap_11 inh_ground inh_power FILLCAP16A10TR
xpcap_10 inh_ground inh_power FILLCAP16A10TR
xpcap_9 inh_ground inh_power FILLCAP16A10TR
xpcap_8 inh_ground inh_power FILLCAP16A10TR
xpcap_7 inh_ground inh_power FILLCAP16A10TR
xpcap_6 inh_ground inh_power FILLCAP16A10TR
xpcap_5 inh_ground inh_power FILLCAP16A10TR
xpcap_4 inh_ground inh_power FILLCAP16A10TR
xpcap_3 inh_ground inh_power FILLCAP16A10TR
xpcap_2 inh_ground inh_power FILLCAP16A10TR
xpcap_1 inh_ground inh_power FILLCAP16A10TR
xfill_t_1_320 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_309 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_205 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_203 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_201 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_186 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_184 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_148 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_145 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_119 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_100 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_98 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_72 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_70 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_67 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_61 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_58 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_50 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_47 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_44 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_39 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_37 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_34 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_31 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_25 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_23 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_21 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_19 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_12 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_10 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_8 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_6 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_4 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_2 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_1 inh_ground inh_power FILLCAP32A10TR
xfill_t_1_323 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_274 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_239 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_199 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_150 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_141 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_104 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_63 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_43 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_28 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_17 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_14 inh_ground inh_power FILLCAP8A10TR
xfill_t_1_324 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_312 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_207 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_192 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_155 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_151 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_142 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_129 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_116 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_106 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_96 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_89 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_80 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_77 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_45 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_29 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_15 inh_ground inh_power FILLCAP4A10TR
xfill_t_1_138 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_78 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_48 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_46 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_18 inh_ground inh_power FILLCAP3A10TR
xfill_t_1_183 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_180 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_147 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_144 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_121 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_118 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_115 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_97 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_95 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_69 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_66 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_60 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_57 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_54 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_52 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_49 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_36 inh_ground inh_power FILLCAP64A10TR
xfill_t_1_33 inh_ground inh_power FILLCAP64A10TR
xrow_in_reg_0_ clk dac_in<4> row_in<0> rst inh_ground inh_power DFFRPQX0P5MA10TR
xrow_in_reg_1_ clk dac_in<5> row_in<1> rst inh_ground inh_power DFFRPQX0P5MA10TR
xrow_in_reg_2_ clk dac_in<6> row_in<2> rst inh_ground inh_power DFFRPQX0P5MA10TR
xrow_in_reg_3_ clk dac_in<7> row_in<3> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcol_in_reg_0_ clk dac_in<0> col_in<0> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcol_in_reg_1_ clk dac_in<1> col_in<1> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcol_in_reg_2_ clk dac_in<2> col_in<2> rst inh_ground inh_power DFFRPQX0P5MA10TR
xcol_in_reg_3_ clk dac_in<3> col_in<3> rst inh_ground inh_power DFFRPQX0P5MA10TR
xtherm1 col_in<3> col_in<2> col_in<1> col_in<0> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> inh_ground inh_power dac_thermometer_0
xtherm0 row_in<3> row_in<2> row_in<1> row_in<0> rows<14> rows<13> rows<12> rows<11> rows<10> rows<9> rows<8> rows<7> rows<6> rows<5> rows<4> rows<3> rows<2> rows<1> rows<0> inh_ground inh_power dac_thermometer_1
.ends dac_therm_top
** End of subcircuit definition.

** Library name: tsmc065_rvt_dnw_stdcells
** Cell name: AO21X0P5MA10TR
** View name: schematic
.subckt AO21X0P5MA10TR a0 a1 b0 y inh_ground inh_power
mna106 int b0 inh_ground inh_ground nch l=60e-9 w=150e-9 m=1 nf=1 sd=390e-9 ad=29.25e-15 as=29.25e-15 pd=690e-9 ps=690e-9 nrd=733.333e-3 nrs=733.333e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb2 n1 a1 inh_ground inh_ground nch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mna1 y int inh_ground inh_ground nch l=60e-9 w=265e-9 m=1 nf=1 sd=200e-9 ad=51.675e-15 as=51.675e-15 pd=920e-9 ps=920e-9 nrd=415.094e-3 nrs=415.094e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mnb1 int a0 n1 inh_ground nch l=60e-9 w=250e-9 m=1 nf=1 sd=200e-9 ad=48.75e-15 as=48.75e-15 pd=890e-9 ps=890e-9 nrd=440e-3 nrs=440e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa108 int b0 p1 inh_power pch l=60e-9 w=365e-9 m=1 nf=1 sd=200e-9 ad=71.175e-15 as=71.175e-15 pd=1.12e-6 ps=1.12e-6 nrd=301.37e-3 nrs=301.37e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb2 p1 a1 inh_power inh_power pch l=60e-9 w=365e-9 m=1 nf=1 sd=200e-9 ad=71.175e-15 as=71.175e-15 pd=1.12e-6 ps=1.12e-6 nrd=301.37e-3 nrs=301.37e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpa1 y int inh_power inh_power pch l=60e-9 w=350e-9 m=1 nf=1 sd=200e-9 ad=68.25e-15 as=68.25e-15 pd=1.09e-6 ps=1.09e-6 nrd=314.286e-3 nrs=314.286e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
mpb1 p1 a0 inh_power inh_power pch l=60e-9 w=365e-9 m=1 nf=1 sd=200e-9 ad=71.175e-15 as=71.175e-15 pd=1.12e-6 ps=1.12e-6 nrd=301.37e-3 nrs=301.37e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends AO21X0P5MA10TR
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_decoder
** View name: schematic
.subckt dac_decoder clk col curr_row in in_b next_row rst inh_ground inh_power
xu6 col curr_row next_row n0 inh_ground inh_power AO21X0P5MA10TR
xu5 in in_b inh_ground inh_power INVX0P5BA10TR
xdac_p_reg clk n0 in rst inh_ground inh_power DFFRPQX0P5MA10TR
.ends dac_decoder
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_cell
** View name: schematic
.subckt dac_cell in in_b iout_n iout_p vcascode vmirror vss!
xm4 iout_n in iout_n vss! nch_mac l=120e-9 w=3.2e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=352e-15 as=488e-15 pd=4.08e-6 ps=6.02e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=12.5214 scb=11.1095e-3 scc=435.729e-6 mismatchflag=1
xm1 iout_p in_b iout_p vss! nch_mac l=120e-9 w=3.2e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=352e-15 as=488e-15 pd=4.08e-6 ps=6.02e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=12.5214 scb=11.1095e-3 scc=435.729e-6 mismatchflag=1
xm5 iout_p in net4 vss! nch_mac l=120e-9 w=6.4e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=704e-15 as=976e-15 pd=7.28e-6 ps=10.82e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=8.60375 scb=6.68777e-3 scc=228.549e-6 mismatchflag=1
xm6 iout_n in_b net4 vss! nch_mac l=120e-9 w=6.4e-6 multi=1 nf=4 sigma=1 sd=220e-9 ad=704e-15 as=976e-15 pd=7.28e-6 ps=10.82e-6 nrd=17.1875e-3 nrs=17.1875e-3 sa=195e-9 sb=195e-9 sca=8.60375 scb=6.68777e-3 scc=228.549e-6 mismatchflag=1
xm9 net1 vmirror vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm15 net4 vcascode net1 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
.ends dac_cell
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_bias
** View name: schematic
.subckt dac_bias vbiasp vcascode vdd! vmirror vss!
xm9 vcascode vbiasp vdd! vdd! pch_mac l=1e-6 w=3.2e-6 multi=1 nf=2 sigma=1 sd=220e-9 ad=352e-15 as=624e-15 pd=3.64e-6 ps=7.18e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=6.93004 scb=5.2439e-3 scc=212.958e-6 mismatchflag=1
xm1 vmirror vbiasp vdd! vdd! pch_mac l=1e-6 w=3.2e-6 multi=1 nf=2 sigma=1 sd=220e-9 ad=352e-15 as=624e-15 pd=3.64e-6 ps=7.18e-6 nrd=34.375e-3 nrs=34.375e-3 sa=195e-9 sb=195e-9 sca=6.93004 scb=5.2439e-3 scc=212.958e-6 mismatchflag=1
xm25 vss! vss! vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm24 vss! vss! vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm22 vmirror vmirror vmirror vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm13 vss! vss! vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm23 vss! vss! vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm21 vcascode vcascode vcascode vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm0 vcascode vcascode net2 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm11 vss! vss! vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm15 net2 vcascode net12 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm20 net8 vmirror vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm19 vmirror vcascode net8 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm16 net12 vcascode net7 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm18 net1 vcascode vss! vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
xm17 net7 vcascode net1 vss! nch_mac l=540e-9 w=1.6e-6 multi=1 nf=1 sigma=1 sd=220e-9 ad=312e-15 as=312e-15 pd=3.59e-6 ps=3.59e-6 nrd=68.75e-3 nrs=68.75e-3 sa=195e-9 sb=195e-9 sca=10.0414 scb=7.41122e-3 scc=228.579e-6 mismatchflag=1
.ends dac_bias
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_cell_row
** View name: schematic
.subckt dac_cell_row clk col<15> col<14> col<13> col<12> col<11> col<10> col<9> col<8> col<7> col<6> col<5> col<4> col<3> col<2> col<1> col<0> iout_n iout_p row<2> row<1> row<0> rst vbiasp vdd! vss! inh_ground inh_power
xdecoder0<15> clk col<15> row<0> in<15> in_b<15> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<14> clk col<14> row<0> in<14> in_b<14> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<13> clk col<13> row<0> in<13> in_b<13> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<12> clk col<12> row<0> in<12> in_b<12> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<11> clk col<11> row<0> in<11> in_b<11> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<10> clk col<10> row<0> in<10> in_b<10> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<9> clk col<9> row<0> in<9> in_b<9> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<8> clk col<8> row<0> in<8> in_b<8> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<7> clk col<7> row<0> in<7> in_b<7> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<6> clk col<6> row<0> in<6> in_b<6> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<5> clk col<5> row<0> in<5> in_b<5> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<4> clk col<4> row<0> in<4> in_b<4> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<3> clk col<3> row<0> in<3> in_b<3> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<2> clk col<2> row<0> in<2> in_b<2> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<1> clk col<1> row<0> in<1> in_b<1> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<0> clk col<0> row<0> in<0> in_b<0> row<1> rst inh_ground inh_power dac_decoder
xdecoder1<15> clk col<15> row<1> in<31> in_b<31> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<14> clk col<14> row<1> in<30> in_b<30> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<13> clk col<13> row<1> in<29> in_b<29> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<12> clk col<12> row<1> in<28> in_b<28> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<11> clk col<11> row<1> in<27> in_b<27> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<10> clk col<10> row<1> in<26> in_b<26> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<9> clk col<9> row<1> in<25> in_b<25> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<8> clk col<8> row<1> in<24> in_b<24> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<7> clk col<7> row<1> in<23> in_b<23> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<6> clk col<6> row<1> in<22> in_b<22> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<5> clk col<5> row<1> in<21> in_b<21> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<4> clk col<4> row<1> in<20> in_b<20> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<3> clk col<3> row<1> in<19> in_b<19> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<2> clk col<2> row<1> in<18> in_b<18> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<1> clk col<1> row<1> in<17> in_b<17> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<0> clk col<0> row<1> in<16> in_b<16> row<2> rst inh_ground inh_power dac_decoder
xcells<31> in<31> in_b<31> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<30> in<30> in_b<30> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<29> in<29> in_b<29> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<28> in<28> in_b<28> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<27> in<27> in_b<27> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<26> in<26> in_b<26> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<25> in<25> in_b<25> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<24> in<24> in_b<24> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<23> in<23> in_b<23> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<22> in<22> in_b<22> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<21> in<21> in_b<21> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<20> in<20> in_b<20> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<19> in<19> in_b<19> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<18> in<18> in_b<18> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<17> in<17> in_b<17> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<16> in<16> in_b<16> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<15> in<15> in_b<15> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<14> in<14> in_b<14> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<13> in<13> in_b<13> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<12> in<12> in_b<12> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<11> in<11> in_b<11> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<10> in<10> in_b<10> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<9> in<9> in_b<9> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<8> in<8> in_b<8> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<7> in<7> in_b<7> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<6> in<6> in_b<6> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<5> in<5> in_b<5> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<4> in<4> in_b<4> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<3> in<3> in_b<3> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<2> in<2> in_b<2> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<1> in<1> in_b<1> iout_n iout_p vcascode vmirror vss! dac_cell
xcells<0> in<0> in_b<0> iout_n iout_p vcascode vmirror vss! dac_cell
xbias vbiasp vcascode vdd! vmirror vss! dac_bias
.ends dac_cell_row
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_cell_first_row
** View name: schematic
.subckt dac_cell_first_row clk col<15> col<14> col<13> col<12> col<11> col<10> col<9> col<8> col<7> col<6> col<5> col<4> col<3> col<2> col<1> col<0> iout_n iout_p row<2> row<1> row<0> rst vbiasp vdd! vss! inh_ground inh_power
xdecoder1<15> clk col<15> row<1> in<31> in_b<31> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<14> clk col<14> row<1> in<30> in_b<30> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<13> clk col<13> row<1> in<29> in_b<29> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<12> clk col<12> row<1> in<28> in_b<28> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<11> clk col<11> row<1> in<27> in_b<27> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<10> clk col<10> row<1> in<26> in_b<26> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<9> clk col<9> row<1> in<25> in_b<25> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<8> clk col<8> row<1> in<24> in_b<24> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<7> clk col<7> row<1> in<23> in_b<23> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<6> clk col<6> row<1> in<22> in_b<22> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<5> clk col<5> row<1> in<21> in_b<21> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<4> clk col<4> row<1> in<20> in_b<20> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<3> clk col<3> row<1> in<19> in_b<19> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<2> clk col<2> row<1> in<18> in_b<18> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<1> clk col<1> row<1> in<17> in_b<17> row<2> rst inh_ground inh_power dac_decoder
xdecoder1<0> clk col<0> row<1> in<16> in_b<16> row<2> rst inh_ground inh_power dac_decoder
xdecoder0<15> clk col<15> row<0> in<15> in_b<15> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<14> clk col<14> row<0> in<14> in_b<14> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<13> clk col<13> row<0> in<13> in_b<13> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<12> clk col<12> row<0> in<12> in_b<12> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<11> clk col<11> row<0> in<11> in_b<11> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<10> clk col<10> row<0> in<10> in_b<10> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<9> clk col<9> row<0> in<9> in_b<9> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<8> clk col<8> row<0> in<8> in_b<8> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<7> clk col<7> row<0> in<7> in_b<7> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<6> clk col<6> row<0> in<6> in_b<6> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<5> clk col<5> row<0> in<5> in_b<5> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<4> clk col<4> row<0> in<4> in_b<4> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<3> clk col<3> row<0> in<3> in_b<3> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<2> clk col<2> row<0> in<2> in_b<2> row<1> rst inh_ground inh_power dac_decoder
xdecoder0<1> clk col<1> row<0> in<1> in_b<1> row<1> rst inh_ground inh_power dac_decoder
xrow0<31> in<31> in_b<31> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<30> in<30> in_b<30> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<29> in<29> in_b<29> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<28> in<28> in_b<28> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<27> in<27> in_b<27> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<26> in<26> in_b<26> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<25> in<25> in_b<25> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<24> in<24> in_b<24> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<23> in<23> in_b<23> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<22> in<22> in_b<22> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<21> in<21> in_b<21> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<20> in<20> in_b<20> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<19> in<19> in_b<19> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<18> in<18> in_b<18> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<17> in<17> in_b<17> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<16> in<16> in_b<16> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<15> in<15> in_b<15> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<14> in<14> in_b<14> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<13> in<13> in_b<13> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<12> in<12> in_b<12> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<11> in<11> in_b<11> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<10> in<10> in_b<10> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<9> in<9> in_b<9> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<8> in<8> in_b<8> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<7> in<7> in_b<7> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<6> in<6> in_b<6> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<5> in<5> in_b<5> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<4> in<4> in_b<4> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<3> in<3> in_b<3> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<2> in<2> in_b<2> iout_n iout_p vcascode vmirror vss! dac_cell
xrow0<1> in<1> in_b<1> iout_n iout_p vcascode vmirror vss! dac_cell
xbias vbiasp vcascode vdd! vmirror vss! dac_bias
.ends dac_cell_first_row
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_analog
** View name: schematic
.subckt dac_analog clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> iout_n iout_p rows<15> rows<14> rows<13> rows<12> rows<11> rows<10> rows<9> rows<8> rows<7> rows<6> rows<5> rows<4> rows<3> rows<2> rows<1> rst vbiasp vdd! vss! inh_ground inh_power
xi109 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<14> rows<13> rows<12> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi107 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<8> rows<7> rows<6> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi110 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<12> rows<11> rows<10> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xrow23 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<4> rows<3> rows<2> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi108 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<16> rows<15> rows<14> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi106 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<6> rows<5> rows<4> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi111 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<10> rows<9> rows<8> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_row
xi98 clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> cols<0> iout_n iout_p rows<2> rows<1> rows<0> rst vbiasp vdd! vss! inh_ground inh_power dac_cell_first_row
vi95 vdd! rows<0> DC=0
vi93 vdd! cols<0> DC=0
vi94 vss! rows<16> DC=0
d1 vss! vdd! pwdnw area=266e-12 pj=73.2e-6 m=1
d0 vss! vdd! pwdnw area=10e-9 pj=400e-6 m=2
d4 vss! vdd! pwdnw area=990.6e-12 pj=128.8e-6 m=1
.ends dac_analog
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac_no_current
** View name: schematic
.subckt dac_no_current clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> iout_n iout_p rst vbiasp vdd! vss! inh_ground inh_power
xi94 clk rst dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> rows<15> rows<14> rows<13> rows<12> rows<11> rows<10> rows<9> rows<8> rows<7> rows<6> rows<5> rows<4> rows<3> rows<2> rows<1> cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> vdd! vss! inh_ground inh_power dac_therm_top
xdac_analog clk cols<15> cols<14> cols<13> cols<12> cols<11> cols<10> cols<9> cols<8> cols<7> cols<6> cols<5> cols<4> cols<3> cols<2> cols<1> iout_n iout_p rows<15> rows<14> rows<13> rows<12> rows<11> rows<10> rows<9> rows<8> rows<7> rows<6> rows<5> rows<4> rows<3> rows<2> rows<1> rst vbiasp vdd! vss! inh_ground inh_power dac_analog
.ends dac_no_current
** End of subcircuit definition.

** Library name: acadia
** Cell name: dac
** View name: schematic
.subckt dac clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> iout_n iout_p ires rst vdd! vss! inh_ground inh_power
xdac_analog clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> iout_n iout_p rst ires vdd! vss! inh_ground inh_power dac_no_current
m0 ires ires vdd! vdd! pch l=1e-6 w=1.6e-6 m=1 nf=1 sd=200e-9 ad=280e-15 as=280e-15 pd=3.55e-6 ps=3.55e-6 nrd=62.5e-3 nrs=62.5e-3 sa=175e-9 sb=175e-9 sca=0 scb=0 scc=0
.ends dac
** End of subcircuit definition.

** Library name: acadia
** Cell name: analog_top
** View name: schematic
.subckt analog_top adc_en ain aip calib_en clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> eoc_n ext_opt ext_vdd_half firm_en iout_n iout_p ires q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> real_vdd_half rst inh_vdd vin vip inh_vss v_bias inh_ground inh_power
xi0 adc_en ain aip calib_en clk eoc_n ext_opt ext_vdd_half firm_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> rst inh_vdd vdd_half inh_vss real_vdd_half vin vip inh_ground inh_power adc
xi1 inh_vdd inh_vss v_bias vdd_half CMOS_1_Refs
xc12 inh_vdd inh_vss nmoscap lr=20e-6 wr=30e-6 m=1
xc11 inh_vdd inh_vss nmoscap lr=20e-6 wr=30e-6 m=1
xc10 inh_vdd inh_vss nmoscap lr=20e-6 wr=30e-6 m=1
xc7 inh_vdd inh_vss nmoscap lr=20e-6 wr=30e-6 m=1
xc6 inh_vdd inh_vss nmoscap lr=50e-6 wr=30e-6 m=1
xc5 inh_vdd inh_vss nmoscap lr=50e-6 wr=30e-6 m=1
xc4 inh_vdd inh_vss nmoscap lr=50e-6 wr=30e-6 m=1
xc3 inh_vdd inh_vss nmoscap lr=50e-6 wr=50e-6 m=1
xc2 inh_vdd inh_vss nmoscap lr=50e-6 wr=50e-6 m=1
xc1 inh_vdd inh_vss nmoscap lr=50e-6 wr=50e-6 m=1
xc0 inh_vdd inh_vss nmoscap lr=50e-6 wr=50e-6 m=1
xi2 clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> iout_n iout_p ires rst inh_vdd inh_vss inh_ground inh_power dac
.ends analog_top
** End of subcircuit definition.

** Library name: acadia
** Cell name: analog_top_mixed
** View name: schematic
.subckt analog_top_mixed adc_en calib_en clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> eoc_n ext_opt firm_en q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> real_vdd_half rst vin vip
xi0 adc_en ain aip calib_en clk dac_in<7> dac_in<6> dac_in<5> dac_in<4> dac_in<3> dac_in<2> dac_in<1> dac_in<0> eoc_n ext_opt net1 firm_en net7 net8 net2 q<7> q<6> q<5> q<4> q<3> q<2> q<1> q<0> real_vdd_half rst vss! vin vip vdd! net4 vss! vdd! analog_top
vaip aip vss! DC=750e-3
vain ain vss! DC=250e-3
v3 net4 vss! DC=120e-3
v2 net1 vss! DC=500e-3
v1 vss! 0 DC=0
v0 vdd! vss! DC=1
r1 net8 vdd 50
r0 vdd! net7 50
i3 net2 vss! DC=12e-6
.ends analog_top_mixed
** End of subcircuit definition.

.option finesim_output=fsdb
.option finesim_merge_fsdb=1
.option post

.END
